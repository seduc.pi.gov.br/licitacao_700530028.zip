Properties of the parts of a building model (IFC4), part 2 of 2

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (180)
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 55.27 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 55.2741 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 10.74 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.7419 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 63.71 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 63.7089 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 100.24 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 100.237 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 49.68 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 49.6756 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 105.65 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 105.646 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 21.98 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 21.9847 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 33.42 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 33.4223 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 32.49 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 32.4885 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 64.45 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 64.4519 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 63.14 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 63.1417 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 25.29 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 25.292 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1.43 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1.42827 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 45.49 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 45.495 cm
3 x  | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 14.98 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 14.9767 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 27.26 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 27.2599 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 36.54 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 36.5391 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 35.45 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 35.4461 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 3.06 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 3.06279 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 15.59 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15.5944 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.03 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 23.0305 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 22.81 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 22.8103 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 21.03 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 21.0304 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 15.81 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 15.8063 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 21.93 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 21.9281 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 14.36 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 14.3606 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 73.74 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 73.7394 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 25.73 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 25.7311 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 13.58 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 13.5822 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 18.66 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 18.6558 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 15.67 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 15.6719 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 14.77 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 14.7718 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 13.45 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 13.4523 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 32.2 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 32.2049 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 83.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 83.302 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | -2.09 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": -2.09437 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 130.84 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 130.838 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 148.81 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 148.806 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 61.84 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 61.8389 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 214.87 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 214.875 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 25 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 25.0041 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 6.77 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 6.77311 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 79.72 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 79.7223 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 15.09 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15.0929 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 53.98 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 53.9762 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 25.05 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 25.0543 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 21.94 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 21.9422 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 17.59 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.5911 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 39.5 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 39.5 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 84.66 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 84.6635 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 85.87 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 85.867 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 10.86 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 10.8599 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 40.3 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 40.3036 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 300 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 300 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1

# IfcPipeSegment: Tubos - diâmetro interno comercial (310)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos - diâmetro interno comercial
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede | PVC rígido soldável - Tubos - 25 mm (cm)
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 84.41 | 25 mm | Água fria | 84.4129
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 93.8 | 25 mm | Água fria | 93.8015
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 73.9 | 25 mm | Água fria | 73.9
4 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 113.9 | 25 mm | Água fria | 113.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 25.43 | 25 mm | Água fria | 25.4349
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 61.41 | 25 mm | Água fria | 61.41
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 59.08 | 25 mm | Água fria | 59.0819
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 14.04 | 25 mm | Água fria | 14.0406
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 23.9 | 25 mm | Água fria | 23.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 22.9 | 25 mm | Água fria | 22.9033
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 91.21 | 25 mm | Água fria | 91.2122
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 6.4 | 25 mm | Água fria | 6.4
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 11.89 | 25 mm | Água fria | 11.8864
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 12.95 | 25 mm | Água fria | 12.9467
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 17.72 | 25 mm | Água fria | 17.7241
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 71.07 | 25 mm | Água fria | 71.0657
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 13.9 | 25 mm | Água fria | 13.9
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 16.4 | 25 mm | Água fria | 16.4
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 11.3 | 25 mm | Água fria | 11.2997
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 93.92 | 25 mm | Água fria | 93.9194
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 105.28 | 25 mm | Água fria | 105.284
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 138.93 | 25 mm | Água fria | 138.928
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 32.5 | 25 mm | Água fria | 32.497
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 112.8 | 25 mm | Água fria | 112.8
6 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 36.65 | 25 mm | Água fria | 36.65
3 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 34.55 | 25 mm | Água fria | 34.55
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 36.4 | 25 mm | Água fria | 36.4
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 138.5 | 25 mm | Água fria | 138.5
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 3.72 | 25 mm | Água fria | 3.71666
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 282.79 | 25 mm | Água fria | 282.785
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 1124.48 | 25 mm | Alimentação | 1124.48
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 216.34 | 50 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 216.34 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 95.39 | 50 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 95.3934 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 13.17 | 50 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 13.1727 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 2.68 | 50 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 2.68436 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | -1.66 | 50 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: -1.65576 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 198.8 | 25 mm | Alimentação | 198.8
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | ø50 | 27.61 | 50 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 27.6114 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 126.76 | 25 mm | Alimentação | 126.757
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 31.84 | 25 mm | Alimentação | 31.8446
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 19.95 | 25 mm | Alimentação | 19.9521
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 21.46 | 25 mm | Alimentação | 21.4577
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 549.95 | 25 mm | Alimentação | 549.947
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 20.22 | 32 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 20.2227 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 22.26 | 25 mm | Água fria | 22.256
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 115.15 | 25 mm | Água fria | 115.15
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 57.36 | 25 mm | Água fria | 57.362
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 23.35 | 25 mm | Água fria | 23.3451
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 215.3 | 25 mm | Água fria | 215.302
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 32.7 | 25 mm | Água fria | 32.7032
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 75.15 | 25 mm | Água fria | 75.15
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 75.39 | 25 mm | Água fria | 75.3898
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 6.2 | 25 mm | Água fria | 6.20346
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 92.84 | 25 mm | Água fria | 92.8412
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 41.03 | 25 mm | Água fria | 41.0347
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 13.9 | 25 mm | Água fria | 13.9004
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 165.47 | 25 mm | Água fria | 165.467
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 24.45 | 25 mm | Água fria | 24.4488
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 68.78 | 25 mm | Água fria | 68.776
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 154.55 | 25 mm | Água fria | 154.55
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 78.5 | 25 mm | Água fria | 78.5
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 10.68 | 25 mm | Água fria | 10.6804
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 49.04 | 25 mm | Água fria | 49.0448
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 95.15 | 25 mm | Água fria | 95.15
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 9.48 | 25 mm | Água fria | 9.47666
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 8.68 | 25 mm | Água fria | 8.67774
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 19.92 | 25 mm | Água fria | 19.9221
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 12.11 | 25 mm | Água fria | 12.1119
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 114.9 | 25 mm | Água fria | 114.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 91.97 | 25 mm | Água fria | 91.9673
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 28.29 | 25 mm | Água fria | 28.2931
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 77.06 | 25 mm | Água fria | 77.0637
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 127.04 | 25 mm | Água fria | 127.038
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 12.15 | 25 mm | Água fria | 12.1471
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 181.75 | 25 mm | Água fria | 181.755
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 16.84 | 25 mm | Água fria | 16.8377
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 20.35 | 25 mm | Água fria | 20.3456
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 114.16 | 25 mm | Água fria | 114.161
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 170.87 | 25 mm | Água fria | 170.869
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 10.85 | 25 mm | Água fria | 10.8493
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 76 | 25 mm | Água fria | 76
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 25.82 | 25 mm | Água fria | 25.8235
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 55 | 25 mm | Água fria | 55.0016
 | TÉRREO | 2.16 | ø3/4" | 0.17 | ø25 | 88.81 | 25 mm | Água fria | 88.8134
2 x  | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 107.4 | 25 mm | Água fria | 107.4
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 45.51 | 25 mm | Água fria | 45.511
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 154.23 | 25 mm | Água fria | 154.232
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 33.9 | 25 mm | Água fria | 33.9
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 220.98 | 25 mm | Água fria | 220.982
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 108.45 | 25 mm | Água fria | 108.448
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 45.57 | 25 mm | Água fria | 45.5715
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 117 | 25 mm | Água fria | 117
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 19.44 | 25 mm | Água fria | 19.4425
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 75.9 | 25 mm | Água fria | 75.9
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 9.5 | 25 mm | Água fria | 9.5
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 384.81 | 25 mm | Água fria | 384.807
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 244.45 | 25 mm | Água fria | 244.452
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 67.4 | 25 mm | Água fria | 67.4
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 97.2 | 25 mm | Água fria | 97.1969
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 172 | 25 mm | Água fria | 172
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 5.54 | 25 mm | Água fria | 5.53665
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 232.4 | 25 mm | Água fria | 232.4
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 72.07 | 25 mm | Água fria | 72.0721
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 46.87 | 25 mm | Alimentação | 46.874
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 728.82 | 25 mm | Água fria | 728.819
2 x  | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 316 | 25 mm | Água fria | 316
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 8.5 | 25 mm | Água fria | 8.5
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 196 | 25 mm | Água fria | 196
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 28.5 | 25 mm | Água fria | 28.5
2 x  | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 74.9 | 25 mm | Água fria | 74.9
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 113.9 | 25 mm | Água fria | 113.9
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 27.64 | 25 mm | Água fria | 27.6351
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 153.9 | 25 mm | Água fria | 153.9
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 12.68 | 25 mm | Água fria | 12.6797
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 98.62 | 25 mm | Água fria | 98.6237
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 6.63 | 25 mm | Água fria | 6.62926
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 10.65 | 25 mm | Água fria | 10.651
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 112.8 | 25 mm | Água fria | 112.8
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 96.77 | 25 mm | Água fria | 96.7678
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 304.61 | 25 mm | Água fria | 304.615
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 222 | 25 mm | Água fria | 222
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 43.74 | 25 mm | Água fria | 43.737
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 26.84 | 25 mm | Água fria | 26.8376
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 152.8 | 25 mm | Água fria | 152.8
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 38.87 | 25 mm | Água fria | 38.866
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 55.9 | 25 mm | Água fria | 55.9
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 504.31 | 25 mm | Água fria | 504.314
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 393.24 | 25 mm | Água fria | 393.235
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 17.88 | 25 mm | Água fria | 17.8785
 | PAVIMENTO 1 | 2.16 | ø3/4" | 0.17 | ø25 | 17.26 | 25 mm | Água fria | 17.2601
2 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 302 | 25 mm | Água fria | 302
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 78.5 | 25 mm | Água fria | 78.5
2 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 18.5 | 25 mm | Água fria | 18.5
5 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 17.5 | 25 mm | Água fria | 17.5
4 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 113.9 | 25 mm | Água fria | 113.9
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 14.73 | 25 mm | Água fria | 14.7344
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 19.52 | 25 mm | Água fria | 19.5173
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 85.52 | 25 mm | Água fria | 85.5197
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 30.6 | 25 mm | Água fria | 30.6016
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 75.33 | 25 mm | Água fria | 75.3328
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 20.74 | 25 mm | Água fria | 20.7449
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 68.86 | 25 mm | Água fria | 68.8556
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 58.9 | 25 mm | Água fria | 58.9
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 51.41 | 25 mm | Água fria | 51.4099
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 25.39 | 25 mm | Água fria | 25.3859
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 102.78 | 25 mm | Água fria | 102.78
2 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 280.5 | 25 mm | Água fria | 280.5
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 7.6 | 25 mm | Água fria | 7.60262
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 18.6 | 25 mm | Água fria | 18.5987
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 12.98 | 25 mm | Água fria | 12.9828
2 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 114.9 | 25 mm | Água fria | 114.9
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 63.38 | 25 mm | Água fria | 63.382
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 118.94 | 25 mm | Água fria | 118.936
4 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 34.55 | 25 mm | Água fria | 34.55
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 152.29 | 25 mm | Água fria | 152.292
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 155.78 | 25 mm | Água fria | 155.779
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 34.65 | 25 mm | Água fria | 34.6455
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 105.43 | 25 mm | Água fria | 105.433
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 18.45 | 25 mm | Água fria | 18.4511
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 65.67 | 25 mm | Água fria | 65.6682
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 44.52 | 25 mm | Água fria | 44.5194
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 27 | 25 mm | Água fria | 27
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 44.12 | 25 mm | Água fria | 44.1164
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 14.3 | 25 mm | Água fria | 14.2998
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 48.16 | 25 mm | Água fria | 48.1636
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 20.94 | 25 mm | Água fria | 20.9382
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 112.8 | 25 mm | Água fria | 112.8
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 86.85 | 25 mm | Água fria | 86.8519
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 140.5 | 25 mm | Água fria | 140.5
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 24.29 | 25 mm | Água fria | 24.2865
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 149.76 | 25 mm | Água fria | 149.755
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 53.14 | 25 mm | Água fria | 53.1374
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 20.71 | 25 mm | Água fria | 20.7069
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 122.8 | 25 mm | Água fria | 122.8
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 36.99 | 25 mm | Água fria | 36.9943
2 x  | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 36.65 | 25 mm | Água fria | 36.65
 | PAVIMENTO 2 | 2.16 | ø3/4" | 0.17 | ø25 | 302 | 25 mm | Alimentação | 302
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 9.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.05417 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 48.34 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 48.34 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 1251.09 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 1251.09 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 66.14 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 66.14 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 2.4 | 25 mm | Água fria | 2.4
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 358.78 | 25 mm | Água fria | 358.779
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 84.43 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 84.4315 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 68.3 | 25 mm | Água fria | 68.3
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 23.51 | 25 mm | Água fria | 23.5117
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 164.19 | 25 mm | Água fria | 164.188
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 67.4 | 25 mm | Água fria | 67.4
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 185.87 | 25 mm | Água fria | 185.873
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 55.5 | 25 mm | Água fria | 55.5
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 69.27 | 25 mm | Água fria | 69.2668
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 242.78 | 25 mm | Água fria | 242.784
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 53.4 | 25 mm | Água fria | 53.4
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 194.22 | 25 mm | Água fria | 194.224
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 379.07 | 25 mm | Água fria | 379.069
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 212.28 | 25 mm | Água fria | 212.276
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 129.56 | 25 mm | Água fria | 129.558
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 43.4 | 25 mm | Água fria | 43.4
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 59.16 | 25 mm | Água fria | 59.1581
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 124.32 | 25 mm | Água fria | 124.321
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 197.21 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 197.206 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 246.1 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 246.096 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 68.4 | 25 mm | Água fria | 68.4
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 8.3 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 8.29679 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 726.49 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 726.489 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 8.4 | 25 mm | Água fria | 8.4
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 21.2 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 21.1986 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 68.03 | 25 mm | Água fria | 68.0349
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 35.39 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 35.3924 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 354.37 | 25 mm | Água fria | 354.372
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 41.66 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 41.66 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 0.98 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 21.25 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 21.2506 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 12.06 | 25 mm | Água fria | 12.0641
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 1.85 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 1.85417 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 224.61 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 224.61 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 8.05 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 8.04916 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 24.33 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 24.329 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 24.64 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 24.6362 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 25.08 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 25.0761 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 97.3 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 97.3 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 11.88 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 11.8772 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 51.48 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 51.4787 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 3.93 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 3.92958 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 23.41 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 23.4063 cm
2 x  | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 8.32 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 8.31782 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | ø32 | 2107.33 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 2107.33 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 56.81 | 25 mm | Água fria (reúso) | 56.8091
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 336.17 | 25 mm | Alimentação | 336.166
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 67.8 | 25 mm | Alimentação | 67.8
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 359.07 | 25 mm | Alimentação | 359.068
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 30.07 | 25 mm | Alimentação | 30.0685
3 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 143.8 | 25 mm | Alimentação | 143.8
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 53.63 | 25 mm | Alimentação | 53.63
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 20.2 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 20.2 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 51.24 | 25 mm | Alimentação | 51.2357
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 49.93 | 25 mm | Água fria (reúso) | 49.9281
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 71.6 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 71.6046 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 152.66 | 25 mm | Água fria (reúso) | 152.66
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 13 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 13 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 86.88 | 25 mm | Água fria (reúso) | 86.8832
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 1068.69 | 25 mm | Água fria (reúso) | 1068.69
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 118.84 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 118.843 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 56.39 | 25 mm | Água fria (reúso) | 56.3859
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 149.06 | 25 mm | Água fria (reúso) | 149.06
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 42.75 | 25 mm | Alimentação | 42.7501
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 69.66 | 25 mm | Água fria (reúso) | 69.661
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 733.16 | 25 mm | Água fria (reúso) | 733.159
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 52.68 | 25 mm | Água fria (reúso) | 52.6789
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 51.53 | 25 mm | Alimentação | 51.53
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 49.14 | 25 mm | Alimentação | 49.1357
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 349.42 | 25 mm | Água fria (reúso) | 349.415
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 315.86 | 25 mm | Alimentação | 315.859
3 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 9.74 | 25 mm | Água fria (reúso) | 9.74
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 21.59 | 25 mm | Água fria (reúso) | 21.5894
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 23.44 | 25 mm | Água fria (reúso) | 23.4429
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 30.92 | 25 mm | Alimentação | 30.915
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 18.41 | 25 mm | Água fria (reúso) | 18.414
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 511.89 | 25 mm | Água fria (reúso) | 511.892
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 103.69 | 25 mm | Água fria (reúso) | 103.694
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 510.76 | 25 mm | Água fria (reúso) | 510.758
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 89.37 | 25 mm | Água fria (reúso) | 89.3729
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 499.34 | 25 mm | Água fria (reúso) | 499.344
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 76.53 | 25 mm | Água fria (reúso) | 76.5293
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 43.97 | 25 mm | Alimentação | 43.9672
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | ø50 | 11.63 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 11.6278 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 322.4 | 25 mm | Alimentação | 322.4
 | COBERTURA | 2.16 | ø3/4" | 0.17 | ø25 | 365.7 | 25 mm | Alimentação | 365.695

# IfcPump: 1.1/2" x 1.1/2", Bh2
In: TÉRREO
Type - PredefinedType: VERTICALINLINE
AltoQi_Builder - Modelo: Recalque - ME 2230 3CV R129 2E; Potência (CV): 3; Comprimento: 47 cm; Diâmetro: 17.2 cm; Indicação: 3CV R129 2E; Posição: Direta
Identificação_Elemento - Aplicação: Bomba hidráulica; Descrição: 1.1/2" x 1.1/2"; Nome: 3CV R129 2E; Classe: Bomba Hidráulica - Recalque; Tipo: 1.1/2" x 1.1/2"; Rede: Alimentação
Pset_PumpTypeCommon - Reference: 1.1/2" x 1.1/2"; NetPositiveSuctionHead: 74721.7; FlowRateRange: 13790
AltoQi_QiBuilder-Itens_Associados - Bomba Hidráulica - Recalque - Schneider - Recalque - ME 2230 3CV: 1

# IfcSanitaryTerminal: Bebedouro
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Bebedouro; Nome: 40mm; Classe: PVC Esgoto; Tipo: Bebedouro; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Bebedouro
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Bebedouro com joelho de 90º, Detalhe H1 (BE)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.1; Indicação: BE; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Bebedouro com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Bebedouro com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Bebedouro com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Bebedouro - 25mmx 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Lavatório com Te de 90º (5)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Lavatório com Te de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Lavatório com Te de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório com Te de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Tê red.90 sold c/ bucha latão B central - 25 mm -1/2": 1
Name | In
3 x  | TÉRREO
2 x  | PAVIMENTO 2

# IfcSanitaryTerminal: Lavatório com joelho de 90º (13)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Lavatório com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Lavatório com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
 | TÉRREO
Detalhe H3 (LV) | TÉRREO
Detalhe H4 (LV) | TÉRREO
2 x Detalhe H6 (LV) | TÉRREO
Detalhe H7 (LV) | TÉRREO
Detalhe H4 (LV) | PAVIMENTO 1
Detalhe H5 (LV) | PAVIMENTO 1
5 x  | PAVIMENTO 2

# IfcSanitaryTerminal: Lavatório de Uso Geral (17)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Lavatório de Uso Geral; Classe: PVC Esgoto; Tipo: Lavatório de Uso Geral; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório de Uso Geral
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
Name | In | Nome
7 x  | TÉRREO | 40mm
 | TÉRREO | 40mm - 110
2 x  | PAVIMENTO 1 | 40mm
7 x  | PAVIMENTO 2 | 40mm

# IfcSanitaryTerminal: Mictório s/sifão, c/caixa de descarga, com joelho de 90º
In: PAVIMENTO 2
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: MIC; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Mictório s/sifão,c/caixa descarga,com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Mictório s/sifão, c/caixa de descarga, com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Mictório s/sifão, c/caixa de descarga, com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Mictório de Descarga Descontínua - 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Pia de Cozinha Industrial - Preparação
In: TÉRREO
Type - PredefinedType: SINK
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Pia de Cozinha Industrial - Preparação com Sifão; Nome: 50mm; Classe: PVC Esgoto; Tipo: Pia de Cozinha Industrial - Preparação; Rede: Esgoto (GORDURA)
Pset_SanitaryTerminalTypeCommon - Reference: Pia de Cozinha Industrial - Preparação
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão p/ pia - 1" x 50 mm: 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 3; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60 cm

# IfcSanitaryTerminal: Pia de Cozinha Industrial - Preparação - 60
In: TÉRREO
Type - PredefinedType: SINK
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Pia de Cozinha Industrial - Preparação com Sifão; Nome: 50mm; Classe: PVC Esgoto; Tipo: Pia de Cozinha Industrial - Preparação - 60; Rede: Esgoto (GORDURA)
Pset_SanitaryTerminalTypeCommon - Reference: Pia de Cozinha Industrial - Preparação - 60
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão p/ pia - 1" x 50 mm: 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 3; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60 cm

# IfcSanitaryTerminal: Pia de cozinha com joelho de 90º (2)
In: TÉRREO
Type - PredefinedType: SINK
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: PIA; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Pia de cozinha com joelho de 90º; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Pia de cozinha com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Pia de cozinha com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Pia de Cozinha - 25mm - 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1
Name

Detalhe H8 (PIA)

# IfcSanitaryTerminal: Saídas livres (3)
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0; Indicação: Saída; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Saídas livres; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Saídas livres; Rede: Água fria (reúso)
Pset_SanitaryTerminalTypeCommon - Reference: Saídas livres
AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento

# IfcSanitaryTerminal: Vaso Sanitário c/ J90º (17)
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ J90º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ J90º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ J90º
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1
Name | In
9 x  | TÉRREO
 | PAVIMENTO 1
7 x  | PAVIMENTO 2

# IfcSanitaryTerminal: Vaso Sanitário c/ junção e curva 45º
In: TÉRREO
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ junção e curva 45º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ junção e curva 45º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ junção e curva 45º
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3; PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1

# IfcSanitaryTerminal: Vaso sanitário com caixa acoplada (19)
Type - PredefinedType: WCSEAT
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: VS; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Vaso sanitário com caixa acoplada; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Vaso sanitário com caixa acoplada; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Vaso sanitário com caixa acoplada
AltoQi_QiBuilder-Itens_Associados - Aparelho - Vaso Sanitário c/ cx. acoplada - 1/2": 1; PVC Acessórios - Engate flexível cobre cromado com canopla - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
10 x  | TÉRREO
2 x  | PAVIMENTO 1
7 x  | PAVIMENTO 2

# IfcStackTerminal: Terminal de ventilação- coluna (6)
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Terminal de ventilação- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Terminal de ventilação- coluna; Rede: Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 50 mm: 1
Name
CV-1
CV-2
CV-3
CV-4
CV-5
CV-6

# IfcTank: Tanque (3)
In: COBERTURA
Type - PredefinedType: STORAGE
AltoQi_Builder - Volume efetivo (l): 10000; Altura: 193 cm; Diâmetro: 278 cm; Indicação: 10000L; Posição: Direta; % do volume do reservatório: 33.33; Localização: Superior; Volume da RTI (m³): 0; Volume da edificação (m³/dia): 0.22; Volume útil estimado (m³): 0.08; Volume (m³): 10
Identificação_Elemento - Aplicação: Reservatório cilíndrico; Descrição: Reservatório 10000L; Nome: 10000L; Classe: Reservatório cilíndrico; Tipo: Tanque; Rede: Água fria
Pset_TankTypeCommon - Reference: Tanque; NominalCapacity: 10; NominalDepht: 193 cm; NominalLenghtOrDiameter: 278 cm
AltoQi_QiBuilder-Itens_Associados - Reservatório cilíndrico - Tanque - 10000 L: 1
Name
RCi1
RCi2
RCi3

# IfcValve: Registro bruto gaveta Industrial c/PVC soldável (5)
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro bruto gaveta Industrial c/PVC soldável; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta Industrial c/PVC soldável
Pset_ValveTypeCommon - Reference: Registro bruto gaveta Industrial c/PVC soldável
Name | In | Nome | Rede | Metais - Registro bruto de gaveta industrial - 1.1/2" | PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2"
 | TÉRREO | 1.1/2" | Alimentação | 1 | 2
3 x  | COBERTURA | 1.1/2" | Água fria | 1 | 2
 | COBERTURA | 1" | Água fria | AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2

# IfcValve: Registro de gaveta c/canopla cromada c/PVC soldável (31)
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de gaveta c/canopla cromada c/PVC soldável; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Registro de gaveta c/canopla cromada c/PVC soldável
Pset_ValveTypeCommon - Reference: Registro de gaveta c/canopla cromada c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 2
Name | In | Rede
12 x  | TÉRREO | Água fria
4 x  | PAVIMENTO 1 | Água fria
9 x  | PAVIMENTO 2 | Água fria
3 x  | COBERTURA | Alimentação
3 x  | COBERTURA | Água fria (reúso)

# IfcValve: Valvula de retenção vertical c/ PVC soldável
In: TÉRREO
Type - PredefinedType: CHECK
AltoQi_Builder - Indicação: VR; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Valvula de retenção vertical c/ PVC soldável; Nome: 1.1/2"; Classe: PVC rígido soldável; Tipo: Valvula de retenção vertical c/ PVC soldável; Rede: Alimentação
Pset_ValveTypeCommon - Reference: Valvula de retenção vertical c/ PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Valvula de retenção vertical - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2

# IfcValve: Válvula de sucção (poço) c/ PVC soldável
In: TÉRREO
Type - PredefinedType: CHECK
AltoQi_Builder - Indicação: VSP; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Válvula de sucção (poço) c/ PVC soldável; Nome: 1"; Classe: PVC rígido soldável; Tipo: Válvula de sucção (poço) c/ PVC soldável; Rede: Alimentação
Pset_ValveTypeCommon - Reference: Válvula de sucção (poço) c/ PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Válvula de sucção - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 1

# IfcWasteTerminal: Caixa Sifonada (15)
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Caixa sifonada; Descrição: Caixa Sifonada; Classe: PVC Esgoto; Tipo: Caixa Sifonada; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixa Sifonada
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1
Name | In | Comprimento (cm) | Diâmetro (cm) | Indicação = Nome | PVC Acessórios - Caixa sifonada - 100x100x50
2 x  | TÉRREO | 15.5 | 15 | 150x150x50 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x150x50: 1
4 x  | TÉRREO | 10 | 10.1 | 100x100x50 | 1
 | PAVIMENTO 1 | 15.5 | 15 | 150x150x50 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x150x50: 1
 | PAVIMENTO 1 | 10 | 10.1 | 100x100x50 | 1
5 x  | PAVIMENTO 2 | 10 | 10.1 | 100x100x50 | 1
2 x  | PAVIMENTO 2 | 15.5 | 15 | 150x150x50 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x150x50: 1

# IfcWasteTerminal: Caixa de passagem (7)
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 34 cm; Largura: 34 cm; Indicação: CE PVC - 30 cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de passagem; Descrição: Caixa de passagem; Nome: CE PVC - 30 cm; Classe: Caixas de Passagem; Tipo: Caixa de passagem; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixa de passagem
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de passagem PVC - 30 cm: 1
