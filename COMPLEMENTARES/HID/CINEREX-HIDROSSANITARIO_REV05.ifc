Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: IFC4
Time: 2026-01-06T14:27:29
Made in: IfcPlusPlus

# IfcBuildingStorey (4)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | -14
PAVIMENTO 1 | PAVIMENTO 1 | 302
PAVIMENTO 2 | PAVIMENTO 2 | 604
COBERTURA | COBERTURA | 930

# IfcBuildingElementProxy: PVC Esgoto - Aparelhos Sanitário
In: PAVIMENTO 1
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário; Nome: Vaso Sanitário - Adaptador PVC - 100 mm; Classe: .BIMFLIX - TEMPLATE HIDRO; Tipo: PVC Esgoto - Aparelhos Sanitário; Rede: Esgoto
Pset_BuildingElementProxyTypeCommon - Reference: PVC Esgoto - Aparelhos Sanitário
AltoQi_QiBuilder-Itens_Associados - . ESGOTO PVC - VEDAÇÃO PARA SAÍDA - VEDAÇÃO P/ SAÍDA DE VASO SANITÁRIO - 100 mm: 1

# IfcInterceptor: Caixas de Gordura (2)
In: TÉRREO
Type - PredefinedType: OIL
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Caixa de passagem; Descrição: Caixas de Gordura; Classe: Caixas de Passagem; Tipo: Caixas de Gordura
Pset_InterceptorTypeCommon - Reference: Caixas de Gordura
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de gordura PVC - CG 30 cm: 1
Name | Indicação = Nome | Rede
 | CG PVC- DN 30 cm | Esgoto (GORDURA) | AltoQi_Builder - Diâmetro: 30 cm
 | CG PVC- 30x30 cm | Esgoto | AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm

# IfcPipeFitting: Curva 45 curta + Curva 45 curta - Pé de coluna (7)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 45 curta + Curva 45 curta - Pé de coluna; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 45 curta + Curva 45 curta - Pé de coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Curva 45 curta Amanco - 100 mm: 2
Name | In | Descrição
2 x  | TÉRREO | Curva 45 curta + Curva 45 curta -
 | TÉRREO | Curva 45 curta + Curva 45 curta - Pé de coluna
 | PAVIMENTO 1 | Curva 45 curta + Curva 45 curta -
3 x  | PAVIMENTO 2 | Curva 45 curta + Curva 45 curta -

# IfcPipeFitting: Curva 45 longa + Curva 45 longa
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 longa + Curva 45 longa; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 45 longa + Curva 45 longa; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 45 longa + Curva 45 longa
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Curva 45 longa - 100 mm: 2

# IfcPipeFitting: Curva 45 soldável
In: PAVIMENTO 1
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 soldável; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Curva 45 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Curva 45 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 45 soldável - 25 mm: 1

# IfcPipeFitting: Curva 90 curta- desce
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 curta- desce; Nome: 40 mm; Classe: PVC Esgoto; Tipo: Curva 90 curta- desce; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 90 curta- desce
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1

# IfcPipeFitting: Curva 90 soldável (126)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 soldável; Classe: PVC rígido soldável; Tipo: Curva 90 soldável
Pset_PipeFittingTypeCommon - Reference: Curva 90 soldável
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Curva 90 soldável - 25 mm
37 x  | TÉRREO | 25 mm | Água fria | 1
 | TÉRREO | 25 mm | Alimentação | 1
2 x  | TÉRREO | 50 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
AL-2 | TÉRREO | 25 mm | Alimentação | 1
18 x  | PAVIMENTO 1 | 25 mm | Água fria | 1
19 x  | PAVIMENTO 2 | 25 mm | Água fria | 1
10 x  | COBERTURA | 25 mm | Água fria | 1
11 x  | COBERTURA | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
14 x  | COBERTURA | 25 mm | Água fria (reúso) | 1
9 x  | COBERTURA | 25 mm | Alimentação | 1
3 x  | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AL-2 | COBERTURA | 25 mm | Alimentação | 1

# IfcPipeFitting: Joelho 45 (62)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45; Classe: PVC Esgoto; Tipo: Joelho 45
Pset_PipeFittingTypeCommon - Reference: Joelho 45
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" = PVC Esgoto - Joelho 45 - 50 mm
12 x  | TÉRREO | 50 mm | Ventilação | 1
4 x  | TÉRREO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
4 x  | TÉRREO | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
 | TÉRREO | 50 mm | Esgoto (GORDURA) | 1
3 x  | TÉRREO | 50 mm | Esgoto | 1
2 x  | PAVIMENTO 1 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
3 x  | PAVIMENTO 1 | 50 mm | Ventilação | 1
 | PAVIMENTO 1 | 50 mm | Esgoto | 1
11 x  | PAVIMENTO 2 | 50 mm | Ventilação | 1
 | PAVIMENTO 2 | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1
4 x  | PAVIMENTO 2 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
7 x  | PAVIMENTO 2 | 50 mm | Esgoto | 1
9 x  | PAVIMENTO 2 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1

# IfcPipeFitting: Joelho 45 soldável (18)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45 soldável; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Joelho 45 soldável
Pset_PipeFittingTypeCommon - Reference: Joelho 45 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 25 mm: 1
Name | In | Rede
3 x  | TÉRREO | Água fria
4 x  | TÉRREO | Alimentação
4 x  | PAVIMENTO 1 | Água fria
5 x  | PAVIMENTO 2 | Água fria
2 x  | COBERTURA | Água fria

# IfcPipeFitting: Joelho 45- desce (15)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45- desce; Classe: PVC Esgoto; Tipo: Joelho 45- desce
Pset_PipeFittingTypeCommon - Reference: Joelho 45- desce
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" = PVC Esgoto - Joelho 45 - 50 mm
6 x  | TÉRREO | 50 mm | Ventilação | 1
 | TÉRREO | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
2 x  | PAVIMENTO 1 | 50 mm | Ventilação | 1
 | PAVIMENTO 1 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
4 x  | PAVIMENTO 2 | 50 mm | Ventilação | 1
 | PAVIMENTO 2 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1

# IfcPipeFitting: Joelho 45- sobe (14)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45- sobe; Classe: PVC Esgoto; Tipo: Joelho 45- sobe
Pset_PipeFittingTypeCommon - Reference: Joelho 45- sobe
Name | In | Indicação = Nome | Rede | PVC Esgoto - Joelho 45 - 40 mm
 | PAVIMENTO 1 | 40 mm | Esgoto | 1
12 x  | PAVIMENTO 2 | 40 mm | Esgoto | 1
 | PAVIMENTO 2 | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 75 mm: 1

# IfcPipeFitting: Joelho 90 (16)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Joelho 90; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Joelho 90
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
Name | In
8 x  | TÉRREO
 | PAVIMENTO 1
7 x  | PAVIMENTO 2

# IfcPipeFitting: Joelho 90- coluna (24)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- coluna; Classe: PVC Esgoto; Tipo: Joelho 90- coluna; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Joelho 90- coluna
Name | In | Indicação = Nome | PVC Esgoto - Anel de borracha - 50mm - 2" = PVC Esgoto - Joelho 90 - 50 mm
10 x  | TÉRREO | 50 mm | 1
2 x  | PAVIMENTO 1 | 50 mm | 1
7 x  | PAVIMENTO 2 | 50 mm | 1
 | PAVIMENTO 2 | 75 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 90 - 75 mm: 1
4 x  | COBERTURA | 50 mm | 1

# IfcPipeFitting: Joelho 90- desce (2)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- desce; Classe: PVC Esgoto; Tipo: Joelho 90- desce
Pset_PipeFittingTypeCommon - Reference: Joelho 90- desce
Name | In | Indicação = Nome | Rede
 | PAVIMENTO 1 | 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 40 mm: 1
 | PAVIMENTO 2 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1

# IfcPipeFitting: Joelho 90- sobe
In: PAVIMENTO 1
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- sobe; Nome: 40 mm; Classe: PVC Esgoto; Tipo: Joelho 90- sobe; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Joelho 90- sobe
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 40 mm: 1

# IfcPipeFitting: Joelho de redução 90 soldável (3)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 32 mm - 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho de redução 90 soldável; Nome: 32 mm - 25 mm; Classe: PVC rígido soldável; Tipo: Joelho de redução 90 soldável
Pset_PipeFittingTypeCommon - Reference: Joelho de redução 90 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho de redução 90 soldável - 32 mm - 25 mm: 1
Name | In | Rede
 | TÉRREO | Alimentação
2 x  | COBERTURA | Água fria

# IfcPipeFitting: Junção simples (7)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples; Classe: PVC Esgoto; Tipo: Junção simples; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Junção simples
Name | In | Indicação = Nome | PVC Esgoto - Anel de borracha - 100mm - 4" | PVC Esgoto - Junção simples - 100 mm- 100 mm
2 x  | TÉRREO | 100 mm - 50 mm | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
3 x  | TÉRREO | 100 mm- 100 mm | 2 | 1
2 x  | PAVIMENTO 2 | 100 mm- 100 mm | 2 | 1

# IfcPipeFitting: Junção simples c/ J45 (23)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples c/ J45; Classe: PVC Esgoto; Tipo: Junção simples c/ J45; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Junção simples c/ J45
Name | In | Indicação | Nome | PVC Esgoto - Anel de borracha - 100mm - 4" | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Joelho 45 - 50 mm = PVC Esgoto - Junção simples - 100 mm - 50 mm
7 x  | TÉRREO | 100 mm- 100 mm | 100 mm - 100 mm | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
4 x  | TÉRREO | 100 mm - 50 mm | 100 mm - 50 mm | 1 | 2 | 1
2 x  | PAVIMENTO 1 | 100 mm - 50 mm | 100 mm - 50 mm | 1 | 2 | 1
 | PAVIMENTO 1 | 100 mm- 100 mm | 100 mm - 100 mm | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
7 x  | PAVIMENTO 2 | 100 mm - 50 mm | 100 mm - 50 mm | 1 | 2 | 1
2 x  | PAVIMENTO 2 | 100 mm- 100 mm | 100 mm - 100 mm | 3 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1

# IfcPipeFitting: Junção simples c/ J45 - Coluna (2)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples c/ J45 - Coluna; Classe: PVC Esgoto; Tipo: Junção simples c/ J45 - Coluna
Pset_PipeFittingTypeCommon - Reference: Junção simples c/ J45 - Coluna
Name | In | Indicação | Nome | Rede
 | PAVIMENTO 1 | 100 mm- 100 mm | 100 mm - 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3; PVC Esgoto - Joelho 45 - 100 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
 | PAVIMENTO 2 | 75 mm - 50 mm | 75 mm - 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Joelho 45 - 50 mm: 1; PVC Esgoto - Junção simples - 75 mm - 50 mm: 1

# IfcPipeFitting: Junção simples- coluna (14)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples- coluna; Classe: PVC Esgoto; Tipo: Junção simples- coluna; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Junção simples- coluna
Name | In | Indicação = Nome | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Joelho 45 - 50 mm = PVC Esgoto - Junção simples - 50 mm - 50 mm
6 x  | TÉRREO | 50 mm - 50 mm | 3 | 1
2 x  | PAVIMENTO 1 | 50 mm - 50 mm | 3 | 1
5 x  | PAVIMENTO 2 | 50 mm - 50 mm | 3 | 1
 | PAVIMENTO 2 | 75 mm 75 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 3; PVC Esgoto - Joelho 45 - 75 mm: 1; PVC Esgoto - Junção simples - 75 mm 75 mm: 1

# IfcPipeFitting: Luva + Bucha de redução sold. longa
In: TÉRREO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 50 mm - 32 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva + Bucha de redução sold. longa; Nome: 50 mm - 32 mm; Classe: PVC rígido soldável; Tipo: Luva + Bucha de redução sold. longa; Rede: Alimentação
Pset_PipeFittingTypeCommon - Reference: Luva + Bucha de redução sold. longa
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 32 mm: 1; PVC rígido soldável - Luva soldável - 50 mm: 1

# IfcPipeFitting: Luva de correr- coluna (2)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva de correr- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Luva de correr- coluna; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Luva de correr- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Luva de correr - 50 mm: 1
Name | In
 | TÉRREO
 | PAVIMENTO 2

# IfcPipeFitting: Luva simples- coluna (3)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva simples- coluna; Classe: PVC Esgoto; Tipo: Luva simples- coluna
Pset_PipeFittingTypeCommon - Reference: Luva simples- coluna
Name | In | Indicação = Nome | Rede
 | PAVIMENTO 1 | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Luva simples - 100 mm: 1
 | PAVIMENTO 1 | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Luva simples - 50 mm: 1
 | PAVIMENTO 2 | 75 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 75mm - 3": 1; PVC Esgoto - Luva simples - 75 mm: 1

# IfcPipeFitting: Luva soldável (21)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva soldável; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Luva soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Luva soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 25 mm: 1
Name | In
AF-1 | TÉRREO
AF-2 | TÉRREO
AF-20 | TÉRREO
AF-3 | TÉRREO
AF-4 | TÉRREO
AF-5 | TÉRREO
AF-6 | TÉRREO
AF-8 | TÉRREO
AF-3 | PAVIMENTO 1
AF-4 | PAVIMENTO 1
AF-6 | PAVIMENTO 1
AF-7 | PAVIMENTO 1
AF-10 | PAVIMENTO 2
AF-11 | PAVIMENTO 2
AF-12 | PAVIMENTO 2
AF-13 | PAVIMENTO 2
AF-3 | PAVIMENTO 2
AF-4 | PAVIMENTO 2
AF-6 | PAVIMENTO 2
AF-7 | PAVIMENTO 2
AF-9 | PAVIMENTO 2

# IfcPipeFitting: Ramais de Ventilação (21)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Ramal de ventilação; Classe: PVC Esgoto; Tipo: Ramais de Ventilação
Pset_PipeFittingTypeCommon - Reference: Ramais de Ventilação
Name | In | Indicação = Nome | Descrição | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Joelho 90 - 50 mm | PVC Esgoto - Tê sanitário - 50 mm - 50 mm
4 x  | TÉRREO | 100mm - 50mm-135° | Ramais de ventilação | Ventilação | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
2 x  | TÉRREO | 100mm - 50mm-90° | Ramais de ventilação | Ventilação | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
3 x  | TÉRREO | 50mm-50mm-135º | Ramais de Ventilação | Ventilação | 3 | 1 | 1
3 x  | TÉRREO | 50mm-50mm-90º | Ramais de Ventilação | Ventilação | 3 | 1 | 1
 | PAVIMENTO 1 | 50mm-50mm-135º | Ramais de Ventilação | Ventilação | 3 | 1 | 1
 | PAVIMENTO 1 | 50mm-50mm-90º | Ramais de Ventilação | Esgoto | 3 | 1 | 1
 | PAVIMENTO 2 | 100mm- 75mm-135º | Ramais de Ventilação | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 75mm - 3": 2; PVC Esgoto - Joelho 90 - 75 mm: 1; PVC Esgoto - Tê sanitário - 100 mm - 75 mm: 1
2 x  | PAVIMENTO 2 | 50mm-50mm-0º | Ramais de Ventilação | Ventilação | 3 | 1 | 1
3 x  | PAVIMENTO 2 | 100mm - 50mm-135° | Ramais de ventilação | Ventilação | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
 | PAVIMENTO 2 | 50mm-50mm-135º | Ramais de Ventilação | Ventilação | 3 | 1 | 1

# IfcPipeFitting: Te 90 soldável (34)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Classe: PVC rígido soldável; Tipo: Te 90 soldável
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Tê 90 soldável - 25 mm
10 x  | TÉRREO | 25 mm | Água fria | 1
8 x  | PAVIMENTO 1 | 25 mm | Água fria | 1
8 x  | PAVIMENTO 2 | 25 mm | Água fria | 1
2 x  | COBERTURA | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
2 x  | COBERTURA | 25 mm | Alimentação | 1
 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
3 x  | COBERTURA | 25 mm | Água fria | 1

# IfcPipeFitting: Te 90 soldável c/ redução lateral (3)
In: COBERTURA
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 50 mm- 32mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável c/ redução lateral; Nome: 50 mm- 32mm; Classe: PVC rígido soldável; Tipo: Te 90 soldável c/ redução lateral; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável c/ redução lateral
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 32 mm: 1; PVC rígido soldável - Tê 90 soldável - 50 mm: 1

# IfcPipeFitting: Te de redução 90 soldável
In: COBERTURA
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 50 mm - 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te de redução 90 soldável; Nome: 50 mm - 25 mm; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te de redução 90 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 25 mm: 1

# IfcPipeFitting: Te de redução 90 soldável c/ redução lateral (2)
In: COBERTURA
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 50 mm - 25 mm- 25mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te de redução 90 soldável c/ redução lateral; Nome: 50 mm - 25 mm- 25mm; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável c/ redução lateral; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te de redução 90 soldável c/ redução lateral
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 25 mm: 1

# IfcPipeFitting: Tomada dágua saída roscável
In: COBERTURA
Type - PredefinedType: ENTRY
AltoQi_Builder - Indicação: 1.1/2"; Posição: Direta
Identificação_Elemento - Aplicação: Tomada d´água; Descrição: Tomada dágua saída roscável; Nome: 1.1/2"; Classe: PVC rígido roscável; Tipo: Tomada dágua saída roscável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Tomada dágua saída roscável
AltoQi_QiBuilder-Itens_Associados - PVC rígido roscável - Adaptador com flanges e anel de vedacao - 1.1/2": 1

# IfcPipeFitting: Torneira bóia
In: TÉRREO
Type - PredefinedType: ENTRY
AltoQi_Builder - Indicação: 3/4"; Posição: Direta
Identificação_Elemento - Aplicação: Tomada d´água; Descrição: Torneira de bóia; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Torneira bóia; Rede: Alimentação
Pset_PipeFittingTypeCommon - Reference: Torneira bóia
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Adapt sold. c/ flange livre p/ cx. d´água - 25 mm - 3/4": 1; PVC rígido soldável - Torneira de bóia - 3/4": 1

# IfcPipeSegment: Tubo rígido c/ ponta lisa (135)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 600 cm; Inclinação: 1
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Rede: Ventilação; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2" (cm)
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 397.23 | 50 mm - 2" | 397.228
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 20.11 | 50 mm - 2" | 20.111
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 125.83 | 50 mm - 2" | 125.834
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 83.49 | 50 mm - 2" | 83.4916
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 54.87 | 50 mm - 2" | 54.8728
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 8.74 | 50 mm - 2" | 8.73896
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 38.28 | 50 mm - 2" | 38.2838
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 176.05 | 50 mm - 2" | 176.055
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 61.59 | 50 mm - 2" | 61.591
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 27.79 | 50 mm - 2" | 27.7923
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 25.86 | 50 mm - 2" | 25.8613
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 262.45 | 50 mm - 2" | 262.451
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 151.62 | 50 mm - 2" | 151.622
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 72.93 | 50 mm - 2" | 72.9252
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 84.58 | 50 mm - 2" | 84.5776
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 129.93 | 50 mm - 2" | 129.93
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 217.6 | 50 mm - 2" | 217.604
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | -0.29 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 707.96 | 50 mm - 2" | 707.963
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 89.46 | 50 mm - 2" | 89.4602
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 82.41 | 50 mm - 2" | 82.4107
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 85.49 | 50 mm - 2" | 85.488
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 377.47 | 50 mm - 2" | 377.471
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 34.89 | 50 mm - 2" | 34.8859
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 47.71 | 50 mm - 2" | 47.7138
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 67.29 | 50 mm - 2" | 67.2927
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 91.23 | 50 mm - 2" | 91.228
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 30.84 | 50 mm - 2" | 30.8355
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 87.11 | 50 mm - 2" | 87.106
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 146.27 | 50 mm - 2" | 146.267
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 83.71 | 50 mm - 2" | 83.7057
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 162.66 | 50 mm - 2" | 162.66
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 227.66 | 50 mm - 2" | 227.66
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 142.66 | 50 mm - 2" | 142.66
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 182.66 | 50 mm - 2" | 182.66
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 42.42 | 50 mm - 2" | 42.4193
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2.42 | 50 mm - 2" | 2.41629
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 169.13 | 50 mm - 2" | 169.127
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 44.06 | 50 mm - 2" | 44.061
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 4.35 | 50 mm - 2" | 4.35063
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 26.44 | 50 mm - 2" | 26.4414
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | -0.14 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 82.03 | 50 mm - 2" | 82.0347
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 2.78 | 50 mm - 2" | 2.77639
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 29.87 | 50 mm - 2" | 29.8707
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 154.48 | 50 mm - 2" | 154.479
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 138.05 | 50 mm - 2" | 138.052
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 115.81 | 50 mm - 2" | 115.813
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 11.12 | 50 mm - 2" | 11.1219
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 127.76 | 50 mm - 2" | 127.759
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 151.06 | 50 mm - 2" | 151.059
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 122.62 | 50 mm - 2" | 122.62
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 103.84 | 50 mm - 2" | 103.841
 | TÉRREO | 4.75 | ø2" | 0.16 | ø50 | 24.51 | 50 mm - 2" | 24.5066
3 x  | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 316 | 50 mm - 2" | 316
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 336.22 | 50 mm - 2" | 336.22
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 334.95 | 50 mm - 2" | 334.949
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 167.57 | 50 mm - 2" | 167.569
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 32.74 | 50 mm - 2" | 32.7367
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 53.46 | 50 mm - 2" | 53.4638
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 23.69 | 50 mm - 2" | 23.6906
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 114.28 | 50 mm - 2" | 114.281
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 318.18 | 50 mm - 2" | 318.179
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 50.78 | 50 mm - 2" | 50.7765
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 134.58 | 50 mm - 2" | 134.584
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 142.66 | 50 mm - 2" | 142.66
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 159.66 | 50 mm - 2" | 159.66
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 16.94 | 50 mm - 2" | 16.9446
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 10.15 | 50 mm - 2" | 10.1501
 | PAVIMENTO 1 | 4.75 | ø2" | 0.16 | ø50 | 1.37 | 50 mm - 2" | 1.37133
3 x  | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 302 | 50 mm - 2" | 302
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 406.55 | 50 mm - 2" | 406.551
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 157.01 | 50 mm - 2" | 157.008
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 143.89 | 50 mm - 2" | 143.891
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 83.77 | 50 mm - 2" | 83.7668
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 45.57 | 50 mm - 2" | 45.567
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 41.12 | 50 mm - 2" | 41.1179
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 39.94 | 50 mm - 2" | 39.9395
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 127.73 | 50 mm - 2" | 127.734
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 122.63 | 50 mm - 2" | 122.633
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 3.37 | 50 mm - 2" | 3.37373
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 11.49 | 50 mm - 2" | 11.4871
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 112.66 | 50 mm - 2" | 112.66
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 117.77 | 50 mm - 2" | 117.769
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | -0.85 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 62.12 | 50 mm - 2" | 62.1202
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 52 | 50 mm - 2" | 51.9952
 | PAVIMENTO 2 | 7.21 | ø3" | 0.17 | ø75 | 55.34 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 55.34 cm
 | PAVIMENTO 2 | 7.21 | ø3" | 0.17 | ø75 | 107.26 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 107.262 cm
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 34.83 | 50 mm - 2" | 34.828
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 369.54 | 50 mm - 2" | 369.54
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 82.92 | 50 mm - 2" | 82.9236
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 15.02 | 50 mm - 2" | 15.0162
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 592.84 | 50 mm - 2" | 592.844
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 18.66 | 50 mm - 2" | 18.6632
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 79.24 | 50 mm - 2" | 79.2437
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 815.62 | 50 mm - 2" | 815.618
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 31.66 | 50 mm - 2" | 31.6603
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 102.36 | 50 mm - 2" | 102.359
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 45.88 | 50 mm - 2" | 45.8822
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 9.3 | 50 mm - 2" | 9.30148
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 107.36 | 50 mm - 2" | 107.356
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 77.14 | 50 mm - 2" | 77.1354
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 90.13 | 50 mm - 2" | 90.1278
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 20.76 | 50 mm - 2" | 20.7606
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 16.46 | 50 mm - 2" | 16.4567
 | PAVIMENTO 2 | 7.21 | ø3" | 0.17 | ø75 | 146 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 146 cm
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 157.66 | 50 mm - 2" | 157.66
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 147.66 | 50 mm - 2" | 147.66
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 166.83 | 50 mm - 2" | 166.83
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 167.66 | 50 mm - 2" | 167.66
 | PAVIMENTO 2 | 7.21 | ø3" | 0.17 | ø75 | 52.2 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 52.2 cm
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 34.84 | 50 mm - 2" | 34.8423
 | PAVIMENTO 2 | 7.21 | ø3" | 0.17 | ø75 | 51.53 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 51.5313 cm
 | PAVIMENTO 2 | 7.21 | ø3" | 0.17 | ø75 | 24.77 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 24.7721 cm
 | PAVIMENTO 2 | 7.21 | ø3" | 0.17 | ø75 | 2.01 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 2.01064 cm
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 4.72 | 50 mm - 2" | 4.71681
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | -1.02 | 50 mm - 2" | -1.01612
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 14.19 | 50 mm - 2" | 14.1885
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 58.99 | 50 mm - 2" | 58.9859
 | PAVIMENTO 2 | 4.75 | ø2" | 0.16 | ø50 | 7.52 | 50 mm - 2" | 7.51841
 | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 120.02 | 50 mm - 2" | 120.015
 | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 242.82 | 50 mm - 2" | 242.823
 | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 356 | 50 mm - 2" | 356
 | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 54.91 | 50 mm - 2" | 54.9095
2 x  | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 96 | 50 mm - 2" | 96
 | COBERTURA | 7.21 | ø3" | 0.17 | ø75 | 92.2 | 75 mm - 3" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 92.2 cm
 | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 39.87 | 50 mm - 2" | 39.8709
 | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 97.33 | 50 mm - 2" | 97.3339
 | COBERTURA | 4.75 | ø2" | 0.16 | ø50 | 248.22 | 50 mm - 2" | 248.217

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (180)
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa e luva simples; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa e luva simples
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 59.34 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 59.3448 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 193.67 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 193.667 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 81.86 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 81.8583 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 268.31 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 268.307 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 63.05 | 50 mm - 2" | Esgoto (GORDURA) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 63.0515 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1352.43 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1352.43 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 4
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1298.02 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1298.02 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 4
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 97.38 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 97.3827 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 112.06 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 112.064 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 93.17 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 93.1747 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 43.61 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 43.6123 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 38.98 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 38.9782 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 74.85 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 74.8532 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 49.53 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 49.5252 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 23.44 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 23.4426 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 12.55 | 173.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 173.297 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 39.09 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 39.0855 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 401.95 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 401.948 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 47.5 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 47.4979 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 21.15 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 21.1543 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 360.03 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 360.032 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 31.97 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 31.9665 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 65.14 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 65.1391 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 41.69 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 41.6902 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 33.51 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 33.5137 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 12.21 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 12.2074 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 44.8 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 44.8007 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 44.5 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 44.501 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 338.98 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 338.978 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 49.38 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 49.379 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 20.56 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 20.5624 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 22.19 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 22.187 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 30.71 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 30.7118 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 50.16 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 50.1593 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 17.45 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 17.4474 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 39.61 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 39.6065 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 114.4 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 114.399 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 65.02 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 65.017 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 113.98 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 113.985 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 21.6 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 21.6002 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 110.75 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 110.755 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 108.06 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 108.056 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 116.8 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 116.802 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 32.48 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 32.4771 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 589.83 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 589.833 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 2
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 6.15 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 6.14565 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 36.67 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 36.6712 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 36.41 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 36.4147 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 13.42 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 13.4171 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 45.84 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.8426 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1087.03 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1087.03 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 3
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 55.66 | 50 mm - 2" | Esgoto (GORDURA) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 55.662 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 20.8 | 138.24 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 138.244 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 45.13 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.1298 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 72.12 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 72.1222 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 17.23 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 17.2334 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 15.23 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15.2327 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 12.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 12.2963 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 42.13 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 42.1328 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 32.7 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 32.6992 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 11.79 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 11.7946 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 8.52 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 8.51711 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 0.41 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 52.82 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 52.8163 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 279.93 | 50 mm - 2" | Esgoto (GORDURA) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 279.928 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 34.98 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 34.9782 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 35.12 | 50 mm - 2" | Esgoto (GORDURA) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.118 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 19.32 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 19.321 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 65.66 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 65.664 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 13.83 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 13.8329 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 37.56 | 31.22 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 31.2166 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 9.64 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 9.63675 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 24.32 | 54.81 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 54.8128 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 39.94 | 50 mm - 2" | Esgoto (GORDURA) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 39.9378 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 29.4 | 45.36 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.3572 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 20.27 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 20.2666 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 228.02 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 228.024 cm
 | TÉRREO | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 140.19 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 140.192 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 13.23 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 13.2281 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 54.67 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 54.6678 cm
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 10.36 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 10.3602 cm
 | TÉRREO | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 131.1 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 131.098 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 296.49 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 296.491 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 339 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 339 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | -5.4 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": -5.40009 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 150.73 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 150.735 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 55.66 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 55.6609 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 130.96 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 130.957 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 56.53 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 56.5255 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 2.47 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 2.46951 cm
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 7.69 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 7.69037 cm
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 12.56 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 12.5608 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 170.33 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 170.327 cm
 | PAVIMENTO 1 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 74.55 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 74.5463 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 263.4 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 263.4 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 41.3 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 41.2956 cm
 | PAVIMENTO 1 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 14.62 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.622 cm
 | PAVIMENTO 1 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 79.2 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 79.1977 cm
 | PAVIMENTO 1 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 11.92 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.9244 cm
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 45.44 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 45.4428 cm
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 31.38 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 31.3782 cm
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 45.35 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 45.3525 cm
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 10.14 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 10.1367 cm
 | PAVIMENTO 1 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 33.21 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 33.2067 cm
 | PAVIMENTO 1 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 67.61 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 67.6119 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 263.62 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 263.625 cm
 | PAVIMENTO 2 | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 2 | 300.19 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 300.194 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 9.85 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.8483 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 225.88 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 225.88 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 59.75 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 59.7518 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 16.11 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 16.1064 cm
4 x  | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 14.24 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 14.2367 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 28.54 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 28.538 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 18 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.0004 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 8.72 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.72111 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 6.68 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.68451 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 2 | 32.2 | 50 mm - 2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 32.2041 cm
4 x  | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 49.85 | 40 mm - 1.1/2" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 49.8479 cm
