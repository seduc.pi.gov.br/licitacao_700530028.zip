Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2026-01-06T10:35:19
Made in: IfcPlusPlus

# IfcBuildingStorey (4)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | -14
PAVIMENTO 1 | PAVIMENTO 1 | 302
PAVIMENTO 2 | PAVIMENTO 2 | 604
COBERTURA | COBERTURA | 930

# IfcBuildingElementProxy: Manômetro (5)
AltoQi_Builder - Comprimento: 60 cm; Largura: 60 cm; Profundidade: 80 cm; Posição: Direta
Identificação_Elemento - Aplicação: Elemento genérico; Descrição: Manômetro; Nome: 1/2"; Classe: Incêndio; Tipo: Manômetro
Pset_BuildingElementProxyTypeCommon - Reference: Manômetro
AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 3/8" x 1/2": 1; Válvula de governo e alarme - Manômetro - 3/8": 1
Name | In | Rede
 | PAVIMENTO 1 | Sprinklers
2 x  | PAVIMENTO 2 | Sprinklers
 | COBERTURA | Hidrantes
 | COBERTURA | Sprinklers

# IfcBuildingElementProxy: Pressostato (5)
AltoQi_Builder - Comprimento: 60 cm; Largura: 60 cm; Profundidade: 80 cm; Posição: Direta
Identificação_Elemento - Aplicação: Elemento genérico; Descrição: Pressostato; Nome: 1/2"; Classe: Incêndio; Tipo: Pressostato
Pset_BuildingElementProxyTypeCommon - Reference: Pressostato
AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 1/4" x 1/2": 1; Válvula de governo e alarme - Pressostato - 1/4": 1
Name | In | Rede
 | PAVIMENTO 1 | Sprinklers
2 x  | PAVIMENTO 2 | Sprinklers
 | COBERTURA | Hidrantes
 | COBERTURA | Sprinklers

# IfcFireSuppressionTerminal: Alarme de incêndio (6)
AltoQi_Builder - Comprimento: 9 cm; Largura: 5 cm; Profundidade: 11 cm; Indicação: A.A.; Posição: Direta
Identificação_Elemento - Aplicação: Detecção e alarme; Descrição: Acionador manual com sirene para alarme de incêndio endereçável; Nome: Acionador manual com sirene para alarme de incêndio endereçável; Classe: Incêndio; Tipo: Alarme de incêndio; Rede: Preventivo
Pset_FireSuppressionTerminalTypeCommon - Reference: Alarme de incêndio
AltoQi_QiBuilder-Itens_Associados - Incêndio - Alarme de incêndio - Acionador manual com sirene para alarme de incêndio endereçável: 1
Name | In
3 x  | TÉRREO
 | PAVIMENTO 1
2 x  | PAVIMENTO 2

# IfcFireSuppressionTerminal: Extintores portáteis (10)
AltoQi_Builder - Comprimento: 44 cm; Diâmetro: 15 cm; Indicação: EXT PQS 6Kg ABC; Posição: Direta
Identificação_Elemento - Aplicação: Extintor; Descrição: Extintor PQS 6kg ABC; Nome: EXT PQS 6Kg ABC; Classe: Incêndio; Tipo: Extintores portáteis; Rede: Preventivo
Pset_FireSuppressionTerminalTypeCommon - Reference: Extintores portáteis
AltoQi_QiBuilder-Itens_Associados - Incêndio - Extintor portátil - Extintor PQS 6kg ABC: 1
Name | In
6 x  | TÉRREO
 | PAVIMENTO 1
2 x  | PAVIMENTO 2
 | COBERTURA

# IfcFireSuppressionTerminal: Hidrante - mangueira 1.1/2 - 2x15m piaui (6)
Type - PredefinedType: FIREHYDRANT
AltoQi_Builder - Comprimento da mangueira: 0 cm; Diâmetro da mangueira: 3.8 cm; Diâmetro do esguicho: 1.157 cm; Comprimento: 60 cm; Largura: 30 cm; Profundidade: 90 cm; Indicação: requinte 1.1/2 - 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Hidrante; Descrição: Hidrante - mangueira 1.1/2 - 2x15m; Nome: requinte 1.1/2 - 40 mm (Risco 2 ) piaui; Classe: Incêndio; Tipo: Hidrante - mangueira 1.1/2 - 2x15m piaui; Rede: Hidrantes
Pset_FireSuppressionTerminalTypeCommon - Reference: Hidrante - mangueira 1.1/2 - 2x15m piaui
AltoQi_QiBuilder-Itens_Associados - Incêndio - Adaptador storz - roscas interna - 2.1/2": 1; Incêndio - Caixa para abrigo de mangueiras - 90 x 60 x 30 cm: 1; Incêndio - Chave para conexão de mangueira tipo storz engate rápido - Dupla - 2.1/2" x 1.1/2": 1; Incêndio - Esguicho jato regulável - 1.1/2" 40mm: 1; Incêndio - Mangueiras - 1.1/2 " 15 m: 2; Incêndio - Niple paralelo em ferro maleável - 2.1/2": 1; Incêndio - Redução giratória tipo Storz - bronze ou latão - 2.1/2" x 1.1/2": 1; Incêndio - Registro globo - 2 1/2" 45º: 1; Incêndio - Tampão cego com corrente tipo storz - 1.1/2": 1
Name | In
Hi2 | TÉRREO
Hi3 | TÉRREO
Hi4 | TÉRREO
Hi6 | PAVIMENTO 1
Hi7 | PAVIMENTO 2
Hi8 | PAVIMENTO 2

# IfcFireSuppressionTerminal: Hidrante de recalque de passeio (2)
In: TÉRREO
Type - PredefinedType: FIREHYDRANT
AltoQi_Builder - Comprimento da mangueira: 100 cm; Diâmetro da mangueira: 6.3 cm; Diâmetro do esguicho: 2.5 cm; Comprimento: 70 cm; Largura: 60 cm; Profundidade: 50 cm; Indicação: 2.1/2"; Posição: Direta
Identificação_Elemento - Aplicação: Hidrante; Descrição: Hidrante de recalque de passeio; Nome: 2.1/2"; Classe: Incêndio; Tipo: Hidrante de recalque de passeio; Rede: Hidrantes
Pset_FireSuppressionTerminalTypeCommon - Reference: Hidrante de recalque de passeio
AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Curva macho - fêmea - 2.1/2": 1; Ferro maleável classe 10 - Niple duplo - 2.1/2": 1; Incêndio - Adaptador storz - roscas interna - 2.1/2": 1; Incêndio - Registro de gaveta com haste ascendente de bronze - 2 1/2": 1; Incêndio - Tampão cego com corrente tipo storz - 2.1/2": 1; Incêndio - Tampão de ferro fundido para passeio com inscrição "hidrante" com telar - 70x60 - cm: 1
Name
Hi1
Hi5

# IfcFireSuppressionTerminal: Iluminação de emergência (31)
AltoQi_Builder - Comprimento: 6 cm; Largura: 3 cm; Profundidade: 21 cm; Indicação: IE; Posição: Direta
Identificação_Elemento - Aplicação: Iluminação de emergência; Descrição: Autônoma 30 LED's 80 lúmens; Nome: Autônoma 30 LED's 80 lúmens_valterdes; Classe: Incêndio; Tipo: Iluminação de emergência; Rede: Preventivo
Pset_FireSuppressionTerminalTypeCommon - Reference: Iluminação de emergência
AltoQi_QiBuilder-Itens_Associados - Incêndio - Iluminação de emergência - Autônoma 30 LED's 80 lúmens: 1
Name | In
18 x  | TÉRREO
6 x  | PAVIMENTO 1
6 x  | PAVIMENTO 2
 | COBERTURA

# IfcFireSuppressionTerminal: Saída de emergência (9)
AltoQi_Builder - Comprimento: 100 cm; Largura: 100 cm; Profundidade: 1 cm; Indicação: SE; Posição: Direta
Identificação_Elemento - Aplicação: Sinalização; Descrição: Sinalização de solo para equipamentos de combate a incêndio; Nome: Sinalização de solo para equipamentos de combate a incêndio; Classe: Incêndio; Tipo: Saída de emergência; Rede: Preventivo
Pset_FireSuppressionTerminalTypeCommon - Reference: Saída de emergência
AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Sinalização de solo para equipamentos de combate a incêndio 100X100: 1
Name | In
6 x  | TÉRREO
 | PAVIMENTO 1
2 x  | PAVIMENTO 2

# IfcFireSuppressionTerminal: Sinalização de emergência (48)
AltoQi_Builder - Largura: 1 cm; Indicação: SE; Posição: Direta
Identificação_Elemento - Aplicação: Sinalização; Classe: Incêndio; Tipo: Sinalização de emergência; Rede: Preventivo
Pset_FireSuppressionTerminalTypeCommon - Reference: Sinalização de emergência
Name | In | Comprimento (cm) | Profundidade (cm) | Descrição | Nome
5 x  | TÉRREO | 24 | 12 | Placa saída de emergência de PVC 24x12cm | Placa saída de emergência de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente saída de emergência de PVC 24x12cm: 1
10 x  | TÉRREO | 15 | 15 | Placa extintor de PVC 15x15cm | Placa extintor de PVC 15x15cm | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente extintor de PVC 15x15cm: 1
5 x  | TÉRREO | 24 | 15 | Placa rota de fuga seta para direita de PVC 24x12cm | Placa rota de fuga seta para direita de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga seta para direita de PVC 24x12cm: 1
4 x  | TÉRREO | 24 | 12 | Placa rota de fuga seta para cima de PVC 24x12cm | Placa rota de fuga seta para cima de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga seta para cima de PVC 24x12cm: 1
3 x  | TÉRREO | 24 | 12 | Placa rota de fuga seta para esquerda de PVC 24x12cm | Placa rota de fuga seta para esquerda de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente saída seta para esquerda de PVC 24x12cm: 1
3 x  | TÉRREO | 15 | 20 | Placa alarme de incêndio de PVC 15x20cm | Placa alarme de incêndio de PVC 15x20cm | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente alarme de incêndio de PVC 15x20cm: 1
2 x  | TÉRREO | 15 | 15 | Placa hidrante de PVC 15x15cm | Placa hidrante de PVC 15x15cm | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente hidrante de PVC 15x15cm: 1
2 x  | TÉRREO | 15 | 15 | Placa mangueira de PVC 15x15cm | Placa mangueira de PVC 15x15cm | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente mangueira de PVC 15x15cm: 1
 | PAVIMENTO 1 | 24 | 12 | Placa rota de fuga pela escada à esquerda seta para baixo de PVC 24 x 12cm | Placa rota de fuga pela escada à esquerda seta para baixo de PVC 24 x 12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga pela escada à esquerda seta para baixo de PVC 24 x 12cm: 1
2 x  | PAVIMENTO 1 | 24 | 12 | Placa rota de fuga seta para cima de PVC 24x12cm | Placa rota de fuga seta para cima de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga seta para cima de PVC 24x12cm: 1
2 x  | PAVIMENTO 1 | 15 | 15 | Placa extintor de PVC 15x15cm | Placa extintor de PVC 15x15cm | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente extintor de PVC 15x15cm: 1
 | PAVIMENTO 1 | 24 | 15 | Placa rota de fuga seta para direita de PVC 24x12cm | Placa rota de fuga seta para direita de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga seta para direita de PVC 24x12cm: 1
2 x  | PAVIMENTO 2 | 24 | 15 | Placa rota de fuga seta para direita de PVC 24x12cm | Placa rota de fuga seta para direita de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga seta para direita de PVC 24x12cm: 1
3 x  | PAVIMENTO 2 | 24 | 12 | Placa rota de fuga seta para cima de PVC 24x12cm | Placa rota de fuga seta para cima de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga seta para cima de PVC 24x12cm: 1
 | PAVIMENTO 2 | 24 | 12 | Placa rota de fuga pela escada à esquerda seta para baixo de PVC 24 x 12cm | Placa rota de fuga pela escada à esquerda seta para baixo de PVC 24 x 12cm | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente rota de fuga pela escada à esquerda seta para baixo de PVC 24 x 12cm: 1
 | PAVIMENTO 2 | 15 | 15 | Placa extintor de PVC 15x15cm | Placa extintor de PVC 15x15cm | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente extintor de PVC 15x15cm: 1
 | PAVIMENTO 2 | 24 | 12 | Placa rota de fuga seta para esquerda de PVC 24x12cm | Placa rota de fuga seta para esquerda de PVC 24x12cm_valterdes | AltoQi_QiBuilder-Itens_Associados - Incêndio - Sinalização de emergência - Placa fotoluminescente saída seta para esquerda de PVC 24x12cm: 1

# IfcFireSuppressionTerminal: Sprinkler DN20 - K115 - Luva de redução (39)
Type - PredefinedType: SPRINKLER
AltoQi_Builder - Diâmetro nominal da rosca: 2 cm; Indicação: 1" x 3/4"; Posição: Direta
Identificação_Elemento - Aplicação: Sprinkler; Descrição: Sprinkler DN20 - K115 - Luva de redução; Nome: 1" x 3/4"; Classe: Ferro maleável classe 10; Tipo: Sprinkler DN20 - K115 - Luva de redução; Rede: Sprinklers
Pset_FireSuppressionTerminalTypeCommon - Reference: Sprinkler DN20 - K115 - Luva de redução
AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Sprinkler - DN 20 - Fator K 115: 1; Ferro maleável classe 10 - luva de redução - 1" x 3/4": 1
Name | In
13 x  | PAVIMENTO 1
26 x  | PAVIMENTO 2

# IfcPipeFitting: Bucha de redução (6)
Type - PredefinedType: TRANSITION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Bucha de redução; Classe: Ferro maleável classe 10; Tipo: Bucha de redução; Rede: Sprinklers
Pset_PipeFittingTypeCommon - Reference: Bucha de redução
Name | In | Indicação = Nome | Ferro maleável classe 10 - Bucha de redução - 2" x 1"
 | PAVIMENTO 1 | 2" x 1" | 1
 | PAVIMENTO 2 | 2.1/2" x 1" | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 2.1/2" x 1": 1
3 x  | PAVIMENTO 2 | 2" x 1" | 1
 | PAVIMENTO 2 | 2" x 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 2" x 1.1/2": 1

# IfcPipeFitting: Cotovelo 90 (103)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Cotovelo 90; Classe: Ferro maleável classe 10; Tipo: Cotovelo 90
Pset_PipeFittingTypeCommon - Reference: Cotovelo 90
Name | In | Indicação = Nome | Rede | Ferro maleável classe 10 - Cotovelo 90 - 1"
4 x  | TÉRREO | 2.1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
6 x  | TÉRREO | 2.1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
25 x  | PAVIMENTO 1 | 1" | Sprinklers | 1
 | PAVIMENTO 1 | 2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2": 1
5 x  | PAVIMENTO 1 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2": 1
 | PAVIMENTO 1 | 2.1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
37 x  | PAVIMENTO 2 | 1" | Sprinklers | 1
4 x  | PAVIMENTO 2 | 2.1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
3 x  | PAVIMENTO 2 | 2.1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
5 x  | PAVIMENTO 2 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2": 1
HI-2 | PAVIMENTO 2 | 2.1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
2 x  | COBERTURA | 3/4" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 3/4": 1
3 x  | COBERTURA | 2.1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
2 x  | COBERTURA | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 3": 1
 | COBERTURA | 2.1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
HI-3 | COBERTURA | 2.1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2.1/2": 1
SP-1 | COBERTURA | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 3": 1
SP-2 | COBERTURA | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 3": 1

# IfcPipeFitting: Cotovelo de redução
In: PAVIMENTO 2
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 1.1/2" x 1"; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Cotovelo de redução; Nome: 1.1/2" x 1"; Classe: Ferro maleável classe 10; Tipo: Cotovelo de redução; Rede: Sprinklers
Pset_PipeFittingTypeCommon - Reference: Cotovelo de redução
AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo de redução - 1.1/2" x 1": 1

# IfcPipeFitting: Luva (9)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva; Classe: Ferro maleável classe 10; Tipo: Luva
Pset_PipeFittingTypeCommon - Reference: Luva
Name | In | Indicação = Nome | Rede | Ferro maleável classe 10 - Luva - 2.1/2"
HI-2 | TÉRREO | 2.1/2" | Hidrantes | 1
HI-3 | TÉRREO | 2.1/2" | Hidrantes | 1
SP-1 | TÉRREO | 2.1/2" | Sprinklers | 1
HI-2 | PAVIMENTO 1 | 2.1/2" | Hidrantes | 1
HI-3 | PAVIMENTO 1 | 2.1/2" | Hidrantes | 1
SP-1 | PAVIMENTO 1 | 2.1/2" | Sprinklers | 1
HI-3 | PAVIMENTO 2 | 2.1/2" | Hidrantes | 1
SP-1 | PAVIMENTO 2 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Luva - 3": 1
SP-2 | PAVIMENTO 2 | 2.1/2" | Sprinklers | 1

# IfcPipeFitting: Luva de redução (2)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva de redução; Classe: Ferro maleável classe 10; Tipo: Luva de redução; Rede: Sprinklers
Pset_PipeFittingTypeCommon - Reference: Luva de redução
Name | In | Indicação = Nome
 | PAVIMENTO 1 | 3" x 2" | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - luva de redução - 3" x 2": 1
 | PAVIMENTO 2 | 3" x 2.1/2" | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - luva de redução - 3" x 2.1/2": 1

# IfcPipeFitting: Te (13)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te; Classe: Ferro maleável classe 10; Tipo: Te
Pset_PipeFittingTypeCommon - Reference: Te
Name | In | Indicação = Nome | Rede | Ferro maleável classe 10 - Tê - 2.1/2"
 | TÉRREO | 2.1/2" | Hidrantes | 1
HI-1 | TÉRREO | 2.1/2" | Hidrantes | 1
 | PAVIMENTO 1 | 2.1/2" | Hidrantes | 1
 | PAVIMENTO 1 | 2.1/2" | Sprinklers | 1
HI-1 | PAVIMENTO 1 | 2.1/2" | Hidrantes | 1
3 x  | PAVIMENTO 2 | 2.1/2" | Hidrantes | 1
HI-1 | PAVIMENTO 2 | 2.1/2" | Hidrantes | 1
 | COBERTURA | 2.1/2" | Sprinklers | 1
 | COBERTURA | 2.1/2" | Hidrantes | 1
 | COBERTURA | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tê - 3": 1
HI-1 | COBERTURA | 2.1/2" | Hidrantes | 1

# IfcPipeFitting: Te com redução lateral (24)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te com redução lateral; Classe: Ferro maleável classe 10; Tipo: Te com redução lateral
Pset_PipeFittingTypeCommon - Reference: Te com redução lateral
Name | In | Indicação = Nome | Rede | Ferro maleável classe 10 - Bucha de redução - 1.1/4" x 1" | Ferro maleável classe 10 - Bucha de redução - 2.1/2" x 1.1/4" = Ferro maleável classe 10 - Tê - 2.1/2"
14 x  | PAVIMENTO 2 | 2.1/2"- 1 " | Sprinklers | 1 | 1
 | PAVIMENTO 2 | 3"- 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 3" x 2.1/2": 1; Ferro maleável classe 10 - Tê - 3": 1
2 x  | PAVIMENTO 2 | 3"- 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tê - 3": 1; Ferro maleável classe 10 - Bucha de redução - 3" x 2": 1
 | PAVIMENTO 2 | 1.1/2"- 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 1.1/2" x 1": 1; Ferro maleável classe 10 - Tê - 1.1/2": 1
2 x  | PAVIMENTO 2 | 2.1/2"- 1/2 " | Sprinklers |  | 1 | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 1.1/4" x 1/2": 1
 | COBERTURA | 2.1/2"- 3/4 " | Hidrantes |  | 1 | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 1.1/4" x 3/4": 1
2 x  | COBERTURA | 2.1/2"- 1/2 " | Hidrantes |  | 1 | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 1.1/4" x 1/2": 1
 | COBERTURA | 3"- 3/4 " | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tê - 3": 1; Ferro maleável classe 10 - Bucha de redução - 1.1/2" x 3/4": 1; Ferro maleável classe 10 - Bucha de redução - 3" x 1.1/2": 1

# IfcPipeFitting: Te de redução (24)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te de redução; Classe: Ferro maleável classe 10; Tipo: Te de redução; Rede: Sprinklers
Pset_PipeFittingTypeCommon - Reference: Te de redução
Name | In | Indicação = Nome | Ferro maleável classe 10 - Tê de redução - 2" x 1"
14 x  | PAVIMENTO 1 | 2" x 1" | 1
8 x  | PAVIMENTO 2 | 2" x 1" | 1
2 x  | COBERTURA | 3" x 1" | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tê de redução - 3" x 1": 1

# IfcPipeFitting: Te de redução central e lateral
In: PAVIMENTO 2
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 3" x 2" x 2"; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te de redução central e lateral; Nome: 3" x 2" x 2"; Classe: Ferro maleável classe 10; Tipo: Te de redução central e lateral; Rede: Sprinklers
Pset_PipeFittingTypeCommon - Reference: Te de redução central e lateral
AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 3" x 2": 1; Ferro maleável classe 10 - Tê de redução - 3" x 2": 1

# IfcPipeSegment: Tubos (258)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 600 cm
Identificação_Elemento - Classe: Ferro maleável classe 10; Tipo: Tubos; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 49.83 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 49.826 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 69.21 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 69.2124 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 79.4 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 79.3972 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 65.44 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 65.4428 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 33.65 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 33.6545 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 41.34 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 41.3402 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 141.54 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 141.54 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 226.66 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 226.662 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 19.23 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 19.2277 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 28.17 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 28.1677 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 151.44 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 151.44 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 659.98 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 659.979 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 116.66 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 116.662 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 304.64 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 304.64 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 237.6 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 237.597 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 34.64 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 34.6397 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 124.64 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 124.64 cm
 | TÉRREO | 6 | ø2 1/2" | 0.375 | ø65 | 82.63 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 82.6326 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 104.74 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 104.74 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 180.74 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 180.74 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 23.59 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 23.5862 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 4.62 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 4.61675 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 339.48 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 339.48 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 274.76 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 274.759 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 135.58 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 135.583 cm
9 x  | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 17.36 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 17.3605 cm
9 x  | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 72.89 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 72.894 cm
2 x  | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 88.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 88.8795 cm
8 x  | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 340.88 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 340.88 cm
 | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 17.36 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 17.36 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 115.51 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 115.512 cm
 | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 73.16 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 73.1604 cm
 | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 27.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 27.88 cm
2 x  | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 34.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 34.8802 cm
7 x  | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 27.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 27.8798 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 267.64 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 267.64 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 37.64 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 37.6402 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 21.54 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 21.54 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 37.7 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 37.7 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 37.74 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 37.7395 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 16.04 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 16.0408 cm
 | PAVIMENTO 1 | 6 | ø2 1/2" | 0.375 | ø65 | 267.74 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 267.74 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 15.08 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 15.0797 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 329.34 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 329.343 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 340.88 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 340.881 cm
 | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 3.36 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 3.35975 cm
 | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 3.36 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 3.36025 cm
2 x  | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 145.63 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 145.628 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 2.08 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 2.08025 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 32.85 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 32.852 cm
 | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 111.26 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 111.256 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 97.69 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 97.6856 cm
2 x  | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 10.94 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 10.9398 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 7.34 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 7.33971 cm
 | PAVIMENTO 1 | 5 | ø2" | 0.375 | ø50 | 15.64 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 15.6409 cm
 | PAVIMENTO 1 | 2.5 | ø1" | 0.335 | ø25 | 17.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 17.8798 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 86.44 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 86.44 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 302.34 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 302.336 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 7.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 7.8805 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 26.04 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 26.0388 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 103.65 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 103.65 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 186.74 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 186.74 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 2516.88 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 2516.88 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 162.94 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 162.936 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 107.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 107.88 cm
6 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 11.48 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 11.48 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 345.77 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 345.77 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 10.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 10.88 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 241.74 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 241.74 cm
3 x  | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 35.36 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 35.3561 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 237.7 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 237.696 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 49.74 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 49.74 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 12.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 12.8803 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 37.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 37.88 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 43.81 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 43.8123 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 12.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 12.88 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 524.54 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 524.54 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 46.54 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 46.5403 cm
9 x  | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 341.54 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 341.54 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | 34.16 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 34.1598 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | 42.83 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 42.83 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 33.05 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 33.0461 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | 7.12 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 7.11915 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 129.29 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 129.292 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 210.97 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 210.97 cm
4 x  | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 361.99 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 361.99 cm
3 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 213.32 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 213.323 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 13.65 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 13.6502 cm
8 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 87.2 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 87.2035 cm
4 x  | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 132.33 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 132.332 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 27.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 27.8798 cm
 | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 35.54 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 35.5361 cm
 | PAVIMENTO 2 | 4 | ø1 1/2" | 0.335 | ø40 | 341.62 | 1 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 40 mm - 1.1/2": 341.62 cm
7 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 37.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 37.8795 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | 21.67 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 21.6737 cm
7 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 23.65 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 23.6502 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | 11.11 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 11.1119 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | -3.25 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": -3.25474 cm
2 x  | PAVIMENTO 2 | 1.5 | ø1/2" | 0.265 | ø15 | 10.77 | 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 15 mm - 1/2": 10.77 cm
3 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 12.88 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 12.8799 cm
 | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 6.58 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 6.58 cm
 | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 8.08 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 8.08 cm
 | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 6.72 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 6.72 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | 149.75 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 149.749 cm
 | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 317.86 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 317.862 cm
 | PAVIMENTO 2 | 7.5 | ø3" | 0.4 | ø80 | 406.69 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 406.69 cm
 | PAVIMENTO 2 | 5 | ø2" | 0.375 | ø50 | 247.33 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 247.331 cm
 | PAVIMENTO 2 | 4 | ø1 1/2" | 0.335 | ø40 | 287.2 | 1 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 40 mm - 1.1/2": 287.204 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 543.6 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 543.602 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 85.93 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 85.9283 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 11.34 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 11.3399 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 197.24 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 197.243 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 9.36 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 9.36 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 110.55 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 110.555 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 345.22 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 345.216 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 4.19 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 4.18676 cm
3 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 31.84 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 31.8445 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 9.79 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 9.79 cm
 | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 9.96 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 9.96025 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 3.65 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 3.65 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 71.97 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 71.9724 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 86.34 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 86.3402 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 118.24 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 118.244 cm
2 x  | PAVIMENTO 2 | 2.5 | ø1" | 0.335 | ø25 | 15.77 | 1" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 25 mm - 1": 15.7698 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 9.42 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 9.41835 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 68.9 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 68.9017 cm
 | PAVIMENTO 2 | 6 | ø2 1/2" | 0.375 | ø65 | 14.58 | 2 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 14.5774 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 2.71 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 2.71 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 5.04 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 5.04 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 31.8 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 31.7994 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 398.23 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 398.226 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 11.44 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 11.44 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 34.64 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 34.6403 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 106.25 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 106.252 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 31.54 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 31.54 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 59.43 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 59.4328 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 10.36 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 10.36 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 333.28 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 333.282 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 34.16 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 34.1602 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 455.28 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 455.281 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 14.15 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 14.15 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 228.42 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 228.417 cm
2 x  | COBERTURA | 1.5 | ø1/2" | 0.265 | ø15 | 15.01 | 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 15 mm - 1/2": 15.01 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 13.11 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 13.1115 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 72.9 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 72.8981 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 27.54 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 27.54 cm
 | COBERTURA | 2 | ø3/4" | 0.265 | ø20 | 27.25 | 3/4" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 20 mm - 3/4": 27.2491 cm
2 x  | COBERTURA | 2 | ø3/4" | 0.265 | ø20 | 13.05 | 3/4" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 20 mm - 3/4": 13.0498 cm
 | COBERTURA | 2 | ø3/4" | 0.265 | ø20 | 20.22 | 3/4" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 20 mm - 3/4": 20.2181 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 15.28 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 15.2759 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | -3.92 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": -3.92 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 26.36 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 26.3598 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 82.67 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 82.6745 cm
 | COBERTURA | 1.5 | ø1/2" | 0.265 | ø15 | 17.12 | 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 15 mm - 1/2": 17.12 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 8.99 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 8.99378 cm
 | COBERTURA | 1.5 | ø1/2" | 0.265 | ø15 | 17.88 | 1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 15 mm - 1/2": 17.8805 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 258.1 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 258.102 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 4.21 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 4.21 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 40.61 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 40.6105 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 80.66 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 80.6582 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 11.94 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 11.9384 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 11.75 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 11.7461 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | -5.83 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": -5.83 cm
 | COBERTURA | 7.5 | ø3" | 0.4 | ø80 | 1.63 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 1.63 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 777.8 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 777.798 cm
 | COBERTURA | 6 | ø2 1/2" | 0.375 | ø65 | 29.41 | 2 1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 65 mm - 2.1/2": 29.4066 cm

# IfcPump: 2.1/2" x 2.1/2" (2)
In: COBERTURA
Type - PredefinedType: VERTICALINLINE
AltoQi_Builder - Potência (CV): 10; Posição: Direta
Identificação_Elemento - Aplicação: Bomba hidráulica; Descrição: 2.1/2" x 2.1/2"; Classe: Bomba Hidráulica - Incêndio; Tipo: 2.1/2" x 2.1/2"
Pset_PumpTypeCommon - Reference: 2.1/2" x 2.1/2"
Name | Modelo | Comprimento (cm) | Diâmetro (cm) | Indicação = Nome | Rede | NetPositiveSuctionHead | FlowRateRange
Bh1 | THSI-18 10CV | 52.3 | 25.5 | 10CV R179 | Hidrantes | 50500.9 | 24180 | AltoQi_QiBuilder-Itens_Associados - Bomba Hidráulica - Incêndio - Bombas TH - THSI-18 10CV: 1
Bh2 | BPI-22 R/F 2.1/2 - 10 CV | 52.5 | 19 | 10CV R162 | Sprinklers | 0 | 0 | AltoQi_QiBuilder-Itens_Associados - Bomba Hidráulica - Incêndio - Bombas SCH - BPI-22 R/F 2.1/2 10CV: 1

# IfcTank: Tanque (3)
In: COBERTURA
Type - PredefinedType: STORAGE
AltoQi_Builder - Volume efetivo (l): 10000; Altura: 193 cm; Diâmetro: 278 cm; Indicação: 10000L; Posição: Direta; % do volume do reservatório: 50; Localização: Superior; Volume da RTI (m³): 0; Volume da edificação (m³/dia): 0.22; Volume útil estimado (m³): 0.11; Volume (m³): 10
Identificação_Elemento - Aplicação: Reservatório cilíndrico; Descrição: Reservatório 10000L; Nome: 10000L; Classe: Reservatório cilíndrico; Tipo: Tanque; Rede: Hidrantes
Pset_TankTypeCommon - Reference: Tanque; NominalCapacity: 10; NominalDepht: 193 cm; NominalLenghtOrDiameter: 278 cm
AltoQi_QiBuilder-Itens_Associados - Reservatório cilíndrico - Tanque - 10000 L: 1
Name
RCi1
RCi2
RCi3

# IfcValve: Registro bruto de gaveta industrial (4)
In: COBERTURA
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro bruto de gaveta industrial; Classe: Ferro maleável classe 10; Tipo: Registro bruto de gaveta industrial
Pset_ValveTypeCommon - Reference: Registro bruto de gaveta industrial
Name | Nome | Rede | Ferro maleável classe 10 - Niple duplo - 2.1/2" | Metais - Registro bruto de gaveta industrial - 2.1/2"
2 x  | 2.1/2" | Hidrantes | 2 | 1
 | 2.1/2" | Sprinklers | 2 | 1
 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Niple duplo - 3": 2; Metais - Registro bruto de gaveta industrial - 3": 1

# IfcValve: Válvula de esfera c/ FºGº (5)
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RGG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Válvula de esfera c/ FºGº; Classe: Ferro maleável classe 10; Tipo: Válvula de esfera c/ FºGº
Pset_ValveTypeCommon - Reference: Válvula de esfera c/ FºGº
Name | In | Nome | Rede
 | PAVIMENTO 1 | 2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - União ass. de ferro conico macho-fêmea - 2": 2; Metais - Válvula de Esfera - 2": 1
 | PAVIMENTO 2 | 2.1/2" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - União ass. de ferro conico macho-fêmea - 2.1/2": 2; Metais - Válvula de Esfera - 2 1/2": 1
 | PAVIMENTO 2 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - União ass. de ferro conico macho-fêmea - 3": 2; Metais - Válvula de Esfera - 3": 1
2 x  | COBERTURA | 3/4" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Luva macho - fêmea - 3/4": 2; Metais - Válvula de Esfera - 3/4": 1

# IfcValve: Válvula de retençao horizontal c/ FºGº (2)
In: TÉRREO
Type - PredefinedType: CHECK
AltoQi_Builder - Indicação: VR; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Válvula de retençao horizontal c/ FºGº; Nome: 2.1/2"; Classe: Ferro maleável classe 10; Tipo: Válvula de retençao horizontal c/ FºGº
Pset_ValveTypeCommon - Reference: Válvula de retençao horizontal c/ FºGº
AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - União ass. de ferro conico macho-fêmea - 2.1/2": 2; Metais - Válvula de retenção horiz c/ portinhola - 2.1/2": 1
Name | Rede
 | Sprinklers
 | Hidrantes

# IfcValve: Válvula de retençao vertical c/ FºGº (2)
In: COBERTURA
Type - PredefinedType: CHECK
AltoQi_Builder - Indicação: VR; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Válvula de retençao vertical c/ FºGº; Classe: Ferro maleável classe 10; Tipo: Válvula de retençao vertical c/ FºGº
Pset_ValveTypeCommon - Reference: Válvula de retençao vertical c/ FºGº
Name | Nome | Rede
 | 3" | Sprinklers | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - União ass. de ferro conico macho-fêmea - 3": 2; Metais - Valvula de retenção vertical - 3": 1
 | 2.1/2" | Hidrantes | AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - União ass. de ferro conico macho-fêmea - 2.1/2": 2; Metais - Valvula de retenção vertical - 2.1/2": 1
