Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2026-01-06T10:22:45
Made in: IfcPlusPlus

# IfcBuildingStorey (4)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | -14
PAVIMENTO 1 | PAVIMENTO 1 | 302
PAVIMENTO 2 | PAVIMENTO 2 | 604
COBERTURA | COBERTURA | 930

# IfcPipeFitting: Adaptador para bocal semi-circular c/ terminação (9)
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 100 mm x 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Adaptador para bocal semi-circular; Nome: 100 mm x 100 mm; Classe: Calha metálica; Tipo: Adaptador para bocal semi-circular c/ terminação; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Adaptador para bocal semi-circular c/ terminação
AltoQi_QiBuilder-Itens_Associados - Calha metálica - Adaptador para bocal semi-circular - 100 mm x 100 mm: 1; Calha metálica - Calha semi-circular - 100 mm: 100 cm

# IfcPipeFitting: Bucha de redução longa (8)
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 40 mm - 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Bucha de redução longa; Nome: 40 mm - 50 mm; Classe: PVC Esgoto; Tipo: Bucha de redução longa
Pset_PipeFittingTypeCommon - Reference: Bucha de redução longa
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1
Name | In | Rede
3 x  | TÉRREO | Pluvial (Ar condicionado)
2 x  | PAVIMENTO 1 | Pluvial
3 x  | PAVIMENTO 2 | Pluvial (Ar condicionado)

# IfcPipeFitting: Cabeceira retangular (6)
In: COBERTURA
Type - PredefinedType: EXIT
AltoQi_Builder - Indicação: 100 mm x 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Cabeceira retangular; Nome: 100 mm x 100 mm; Classe: Calha metálica; Tipo: Cabeceira retangular; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Cabeceira retangular
AltoQi_QiBuilder-Itens_Associados - Calha metálica - Cabeceira retangular - 100 mm x 100 mm: 1

# IfcPipeFitting: Curva 45 Longa para Esgoto Sanitário
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 150mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 Longa para Esgoto Sanitário; Nome: 150mm; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Curva 45 Longa para Esgoto Sanitário
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Curva 45 longa - 150 mm: 1

# IfcPipeFitting: Curva 45º curta Amanco (6)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45º curta Amanco; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 45º curta Amanco; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Curva 45º curta Amanco
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 45 curta Amanco - 100 mm: 1
Name | In
3 x  | TÉRREO
3 x  | COBERTURA

# IfcPipeFitting: Curva 90 curta
In: COBERTURA
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 curta; Nome: 40 mm; Classe: PVC Esgoto; Tipo: Curva 90 curta; Rede: Pluvial (Ar condicionado)
Pset_PipeFittingTypeCommon - Reference: Curva 90 curta
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1

# IfcPipeFitting: Curva 90 curta- coluna (7)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 curta- coluna; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 90 curta- coluna; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Curva 90 curta- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
Name | In
 | TÉRREO
AP-10 | TÉRREO
AP-2 | TÉRREO
AP-6 | TÉRREO
AP-8 | TÉRREO
AP-9 | TÉRREO
AP-10 | PAVIMENTO 1

# IfcPipeFitting: Curva 90 curta- desce (21)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 curta- desce; Classe: PVC Esgoto; Tipo: Curva 90 curta- desce
Pset_PipeFittingTypeCommon - Reference: Curva 90 curta- desce
Name | In | Indicação = Nome | Rede | PVC Esgoto - Curva 90 curta - 40 mm
7 x  | TÉRREO | 40 mm | Pluvial (Ar condicionado) | 1
 | TÉRREO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
AP-1 | TÉRREO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
2 x  | PAVIMENTO 1 | 40 mm | Pluvial | 1
 | PAVIMENTO 1 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
 | PAVIMENTO 2 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
AP-11 | PAVIMENTO 2 | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
2 x  | COBERTURA | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
2 x  | COBERTURA | 40 mm | Pluvial (Ar condicionado) | 1
AP-6 | COBERTURA | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
AP-7 | COBERTURA | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
AP-9 | COBERTURA | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1

# IfcPipeFitting: Curva 90 longa- coluna (2)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 150 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 longa- coluna; Nome: 150 mm; Classe: PVC Esgoto; Tipo: Curva 90 longa- coluna; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Curva 90 longa- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Curva 90 longa - 150 mm: 1
Name
AP-3
AP-4

# IfcPipeFitting: Curva 90 soldável (2)
In: PAVIMENTO 1
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 32 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 soldável; Nome: 32 mm; Classe: PVC rígido soldável; Tipo: Curva 90 soldável
Pset_PipeFittingTypeCommon - Reference: Curva 90 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
Name | Rede
 | Pluvial
APS1-4 | Pluvial (Ar condicionado)

# IfcPipeFitting: Joelho 45 (21)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45; Classe: PVC Esgoto; Tipo: Joelho 45
Pset_PipeFittingTypeCommon - Reference: Joelho 45
Name | In | Indicação = Nome | Rede | PVC Esgoto - Joelho 45 - 40 mm
4 x  | TÉRREO | 40 mm | Pluvial (Ar condicionado) | 1
 | TÉRREO | 100 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
 | TÉRREO | 50 mm | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
7 x  | PAVIMENTO 1 | 40 mm | Pluvial | 1
4 x  | PAVIMENTO 2 | 40 mm | Pluvial (Ar condicionado) | 1
2 x  | COBERTURA | 50 mm | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
2 x  | COBERTURA | 40 mm | Pluvial (Ar condicionado) | 1

# IfcPipeFitting: Joelho 45 soldável (2)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45 soldável; Nome: 50 mm; Classe: PVC rígido soldável; Tipo: Joelho 45 soldável
Pset_PipeFittingTypeCommon - Reference: Joelho 45 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 50 mm: 1
Name | In | Rede
 | PAVIMENTO 1 | Pluvial
 | PAVIMENTO 2 | Pluvial (Ar condicionado)

# IfcPipeFitting: Joelho 45- desce (15)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45- desce; Classe: PVC Esgoto; Tipo: Joelho 45- desce
Pset_PipeFittingTypeCommon - Reference: Joelho 45- desce
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 100mm - 4" = PVC Esgoto - Joelho 45 - 100 mm
 | TÉRREO | 100 mm | Pluvial | 1
AP-7 | TÉRREO | 100 mm | Pluvial | 1
 | PAVIMENTO 2 | 50 mm | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
8 x  | COBERTURA | 100 mm | Pluvial | 1
 | COBERTURA | 150 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Joelho 45 - 150 mm: 1
AP-1 | COBERTURA | 100 mm | Pluvial | 1
AP-2 | COBERTURA | 100 mm | Pluvial | 1
AP-4 | COBERTURA | 150 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Joelho 45 - 150 mm: 1

# IfcPipeFitting: Joelho 90 soldável (50)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90 soldável; Classe: PVC rígido soldável; Tipo: Joelho 90 soldável; Rede: Pluvial (Ar condicionado)
Pset_PipeFittingTypeCommon - Reference: Joelho 90 soldável
Name | In | Indicação = Nome | PVC rígido soldável - Joelho 90º soldável - 32 mm
9 x  | TÉRREO | 32 mm | 1
21 x  | PAVIMENTO 1 | 32 mm | 1
19 x  | PAVIMENTO 2 | 32 mm | 1
 | PAVIMENTO 2 | 40 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 40 mm: 1

# IfcPipeFitting: Joelho 90- coluna (3)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- coluna; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Joelho 90- coluna; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Joelho 90- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1
Name | In
AP-11 | PAVIMENTO 1
2 x  | COBERTURA

# IfcPipeFitting: Joelho 90- sobe (4)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- sobe; Nome: 40 mm; Classe: PVC Esgoto; Tipo: Joelho 90- sobe; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Joelho 90- sobe
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 40 mm: 1
Name | In
2 x  | PAVIMENTO 1
2 x  | PAVIMENTO 2

# IfcPipeFitting: Junção simples (7)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples; Classe: PVC Esgoto; Tipo: Junção simples
Pset_PipeFittingTypeCommon - Reference: Junção simples
Name | In | Indicação = Nome | Rede | PVC Esgoto - Junção simples - 40 mm x 40 mm
2 x  | TÉRREO | 100 mm - 50 mm | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
 | TÉRREO | 40 mm x 40 mm | Pluvial (Ar condicionado) | 1
2 x  | PAVIMENTO 1 | 40 mm x 40 mm | Pluvial | 1
2 x  | PAVIMENTO 2 | 40 mm x 40 mm | Pluvial (Ar condicionado) | 1

# IfcPipeFitting: Junção simples- coluna (8)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 100 mm - 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples- coluna; Nome: 100 mm - 50 mm; Classe: PVC Esgoto; Tipo: Junção simples- coluna
Pset_PipeFittingTypeCommon - Reference: Junção simples- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Joelho 45 - 50 mm: 1; PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
Name | In | Rede
 | TÉRREO | Pluvial (Ar condicionado)
2 x  | PAVIMENTO 1 | Pluvial
4 x  | PAVIMENTO 2 | Pluvial (Ar condicionado)
 | COBERTURA | Pluvial (Ar condicionado)

# IfcPipeFitting: Luva simples- coluna (18)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva simples- coluna; Classe: PVC Esgoto; Tipo: Luva simples- coluna; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Luva simples- coluna
Name | In | Indicação = Nome | PVC Esgoto - Anel de borracha - 100mm - 4" = PVC Esgoto - Luva simples - 100 mm
AP-5 | TÉRREO | 100 mm | 1
AP-1 | PAVIMENTO 1 | 100 mm | 1
AP-2 | PAVIMENTO 1 | 100 mm | 1
AP-3 | PAVIMENTO 1 | 150 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Luva simples - 150 mm: 1
AP-4 | PAVIMENTO 1 | 150 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Luva simples - 150 mm: 1
AP-5 | PAVIMENTO 1 | 100 mm | 1
AP-6 | PAVIMENTO 1 | 100 mm | 1
AP-7 | PAVIMENTO 1 | 100 mm | 1
AP-8 | PAVIMENTO 1 | 100 mm | 1
AP-9 | PAVIMENTO 1 | 100 mm | 1
AP-1 | PAVIMENTO 2 | 100 mm | 1
AP-2 | PAVIMENTO 2 | 100 mm | 1
AP-4 | PAVIMENTO 2 | 150 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Luva simples - 150 mm: 1
AP-6 | PAVIMENTO 2 | 100 mm | 1
AP-8 | PAVIMENTO 2 | 100 mm | 1
AP-9 | PAVIMENTO 2 | 100 mm | 1
AP-3 | COBERTURA | 150 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 150mm - 6": 1; PVC Esgoto - Luva simples - 150 mm: 1
AP-8 | COBERTURA | 100 mm | 1

# IfcPipeFitting: Te 90 soldável (3)
In: PAVIMENTO 1
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 32 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Nome: 32 mm; Classe: PVC rígido soldável; Tipo: Te 90 soldável; Rede: Pluvial (Ar condicionado)
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
Name
APS1-1
APS1-2
APS1-3

# IfcPipeFitting: Te 90 soldável c/ redução lateral (9)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 40 mm- 32mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável c/ redução lateral; Nome: 40 mm- 32mm; Classe: PVC rígido soldável; Tipo: Te 90 soldável c/ redução lateral; Rede: Pluvial (Ar condicionado)
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável c/ redução lateral
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 40 mm - 32 mm: 1; PVC rígido soldável - Tê 90 soldável - 40 mm: 1
Name | In
2 x  | TÉRREO
5 x  | PAVIMENTO 1
2 x  | PAVIMENTO 2

# IfcPipeFitting: Te sanitário- coluna
In: COBERTURA
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 100 mm - 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário- coluna; Nome: 100 mm - 100 mm; Classe: PVC Esgoto; Tipo: Te sanitário- coluna; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Te sanitário- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Tê sanitário - 100 mm - 100 mm: 1

# IfcPipeSegment: Calha retangular (10)
In: COBERTURA
Type - PredefinedType: GUTTER
AltoQi_Builder - Comprimento máximo: 300 cm; Espessura: 0.15 cm; Inclinação: 1
Identificação_Elemento - Classe: Calha metálica; Tipo: Calha retangular; Rede: Pluvial; Aplicação: Calha retangular aberta
Pset_PipeSegmentTypeCommon - Reference: Calha retangular
Pset_PipeSegmentTypeGutter - Slope: 0.01 rad
Name | Altura (cm) | Base (cm) | Indicação | Comprimento (cm) | Nome | Calha metálica - Calha retangular - 100 mm x 100 mm (cm)
 | 7.5 | 8 | 75 x 80 | 635.86 | 75 mm x 80 mm | AltoQi_QiBuilder-Itens_Associados - Calha metálica - Calha retangular - 75 mm x 80 mm: 635.864 cm
 | 7.5 | 8 | 75 x 80 | 624.95 | 75 mm x 80 mm | AltoQi_QiBuilder-Itens_Associados - Calha metálica - Calha retangular - 75 mm x 80 mm: 624.948 cm
 | 25 | 25 | 250 x 250 | 2255.81 | 250 mm x 250 mm | 2255.81
 | 25 | 25 | 250 x 250 | 2273.09 | 250 mm x 250 mm | 2273.09
 | 25 | 25 | 250 x 250 | 2306.06 | 250 mm x 250 mm | 2306.06
 | 25 | 25 | 250 x 250 | 478.06 | 250 mm x 250 mm | 478.059
 | 25 | 25 | 250 x 250 | 839.07 | 250 mm x 250 mm | 839.074
 | 25 | 25 | 250 x 250 | 265.21 | 250 mm x 250 mm | 265.214
 | 25 | 25 | 250 x 250 | 358.12 | 250 mm x 250 mm | 358.116
 | 25 | 25 | 250 x 250 | 268.12 | 250 mm x 250 mm | 268.116

# IfcPipeSegment: Tubo PVC ponta-bolsa (155)
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo PVC ponta-bolsa; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo PVC ponta-bolsa
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede | PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 100 mm - 4" (cm)
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 101.76 | 100 mm - 4" | Pluvial | 101.764
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 381.48 | 100 mm - 4" | Pluvial | 381.48
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 40.98 | 100 mm - 4" | Pluvial | 40.9774
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 35.6 | 100 mm - 4" | Pluvial | 35.6001
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 130.98 | 100 mm - 4" | Pluvial | 130.982
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 1408.49 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 1408.49 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 100.81 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 100.807 cm
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 262.9 | 100 mm - 4" | Pluvial | 262.9
 | TÉRREO | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 1 | 97.09 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 97.0947 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 18.08 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 18.0757 cm
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 566.8 | 100 mm - 4" | Pluvial | 566.799
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 17.4 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 17.4039 cm
 | TÉRREO | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 1 | 34.8 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 34.8009 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 506.69 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 506.693 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 24.17 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 24.1661 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 57.97 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 57.9721 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 66.06 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 66.0552 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 192.4 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 192.4 cm
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 23 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 23.0048 cm
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 415.98 | 100 mm - 4" | Pluvial | 415.982
 | TÉRREO | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 84.95 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 84.9507 cm
 | TÉRREO | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 895.04 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 895.036 cm; PVC Esgoto - Anel de borracha - 150mm - 6": 1
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 77.74 | 100 mm - 4" | Pluvial | 77.745
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 925.07 | 100 mm - 4" | Pluvial | 925.066 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 272.4 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 272.4 cm
 | TÉRREO | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 963.39 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 963.387 cm; PVC Esgoto - Anel de borracha - 150mm - 6": 1
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 288.97 | 100 mm - 4" | Pluvial | 288.973
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 526.37 | 100 mm - 4" | Pluvial | 526.373
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 911.48 | 100 mm - 4" | Pluvial | 911.477 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 27.71 | 79.8 | 100 mm - 4" | Pluvial | 79.8041
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1962.54 | 100 mm - 4" | Pluvial | 1962.54 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 312.4 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 312.4 cm
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 18.15 | 100 mm - 4" | Pluvial | 18.1545
 | TÉRREO | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 64.23 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 64.2264 cm
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.01 | 100 mm - 4" | Pluvial | 23.0068
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 454.69 | 100 mm - 4" | Pluvial | 454.689
 | TÉRREO | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 1 | 36.64 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 36.6403 cm
 | TÉRREO | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 291.6 | 100 mm - 4" | Pluvial | 291.6
 | TÉRREO | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 1 | 29.08 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 29.0848 cm
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 54.92 | 100 mm - 4" | Pluvial | 54.9247
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 398.9 | 100 mm - 4" | Pluvial | 398.9
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 86.7 | 100 mm - 4" | Pluvial | 86.7
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 155.6 | 100 mm - 4" | Pluvial | 155.6
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 227.9 | 100 mm - 4" | Pluvial | 227.9
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 612.01 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 612.013 cm
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 453.9 | 100 mm - 4" | Pluvial | 453.9
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 66.84 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 66.8371 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 615.45 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 615.448 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 61.16 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 61.1624 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 590.03 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 590.027 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 71.45 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 71.4464 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 74.26 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 74.2621 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 415.42 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 415.416 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 9.43 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 9.43281 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 293.14 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 293.135 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 305.72 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 305.718 cm
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 247.68 | 100 mm - 4" | Pluvial | 247.675
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 477.46 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 477.464 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 184.61 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 184.614 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 452.39 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 452.395 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 105.51 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 105.514 cm
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 239.52 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 239.525 cm
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 2 | 372.9 | 100 mm - 4" | Pluvial | 372.9
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 387.9 | 100 mm - 4" | Pluvial | 387.9
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 847.27 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 847.269 cm
 | PAVIMENTO 1 | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 391 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 391 cm
 | PAVIMENTO 1 | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 376 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 376 cm
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 38.95 | 100 mm - 4" | Pluvial | 38.9533
 | PAVIMENTO 1 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 217.19 | 40 mm - 1.1/2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 217.187 cm
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 239.8 | 100 mm - 4" | Pluvial | 239.8
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 126.3 | 100 mm - 4" | Pluvial | 126.298
 | PAVIMENTO 1 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 41.9 | 100 mm - 4" | Pluvial | 41.9
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 21.51 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 21.5072 cm
 | PAVIMENTO 2 | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 1 | 94.27 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 94.2703 cm
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | -1.63 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: -1.62747 cm
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 16.22 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 16.2226 cm
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 401.9 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 401.902 cm
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 2 | 80 | 100 mm - 4" | Pluvial | 80
3 x  | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 302 | 100 mm - 4" | Pluvial | 302
2 x  | PAVIMENTO 2 | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 302 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 302 cm
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 63.6 | 100 mm - 4" | Pluvial | 63.6001
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 40 | 100 mm - 4" | Pluvial | 40
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 223.16 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 223.157 cm
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 35.6 | 100 mm - 4" | Pluvial | 35.5999
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 61.66 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 61.6584 cm
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 54.47 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 54.473 cm
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 43.6 | 100 mm - 4" | Pluvial | 43.5999
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 38.15 | 100 mm - 4" | Pluvial | 38.146
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 14.97 | 100 mm - 4" | Pluvial | 14.974
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 276.91 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 276.914 cm
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 102.7 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 102.698 cm
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 472.53 | 100 mm - 4" | Pluvial | 472.526
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 21.75 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 21.7502 cm
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 19.5 | 100 mm - 4" | Pluvial | 19.5001
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 64.69 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 64.6854 cm
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 51.44 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 51.4358 cm
 | PAVIMENTO 2 | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 369.27 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 369.267 cm
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 245 | 100 mm - 4" | Pluvial | 245
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 486 | 100 mm - 4" | Pluvial | 486
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 253 | 100 mm - 4" | Pluvial | 253
 | PAVIMENTO 2 | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 2 | 472 | 100 mm - 4" | Pluvial | 472
2 x  | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 134.7 | 100 mm - 4" | Pluvial | 134.7
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 54.27 | 100 mm - 4" | Pluvial | 54.2701
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 70.7 | 100 mm - 4" | Pluvial | 70.7
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 53.04 | 100 mm - 4" | Pluvial | 53.0419
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 320.7 | 100 mm - 4" | Pluvial | 320.7
 | COBERTURA | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 326 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 326 cm
 | COBERTURA | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 27.11 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 27.1061 cm
 | COBERTURA | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 318.93 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 318.93 cm
 | COBERTURA | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 51.7 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 51.6999 cm
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 27.7 | 100 mm - 4" | Pluvial | 27.7001
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 43.7 | 100 mm - 4" | Pluvial | 43.7001
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 46.49 | 100 mm - 4" | Pluvial | 46.4925
2 x  | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 52.45 | 100 mm - 4" | Pluvial | 52.4455
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 140.01 | 100 mm - 4" | Pluvial | 140.011
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 2176.44 | 100 mm - 4" | Pluvial | 2176.44 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 97 | 100 mm - 4" | Pluvial | 96.9983
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 39.7 | 100 mm - 4" | Pluvial | 39.7001
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 300.07 | 100 mm - 4" | Pluvial | 300.066
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 47.39 | 100 mm - 4" | Pluvial | 47.3871
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 141.52 | 100 mm - 4" | Pluvial | 141.518
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 2211.63 | 100 mm - 4" | Pluvial | 2211.63 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 3
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 307.2 | 100 mm - 4" | Pluvial | 307.2
2 x  | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 25 | 100 mm - 4" | Pluvial | 25
6 x  | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 20 | 100 mm - 4" | Pluvial | 20
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 17 | 100 mm - 4" | Pluvial | 17
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 43.2 | 100 mm - 4" | Pluvial | 43.2
 | COBERTURA | 592.5 | 14.5 | ø6" | 0.25 | ø150 | 1 | 65 | 150 mm - 6" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 150 mm - 6": 65 cm
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 30 | 100 mm - 4" | Pluvial | 29.9999
 | COBERTURA | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 364.76 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 364.758 cm
 | COBERTURA | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 32.4 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 32.3995 cm
 | COBERTURA | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 166.97 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 166.973 cm
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 13.33 | 100 mm - 4" | Pluvial | 13.328
 | COBERTURA | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 126.37 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 126.368 cm
 | COBERTURA | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 312.65 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 312.651 cm
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 289.2 | 100 mm - 4" | Pluvial | 289.2
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 34 | 100 mm - 4" | Pluvial | 33.9997
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 10.8 | 100 mm - 4" | Pluvial | 10.7987
 | COBERTURA | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 92.4 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 92.4 cm
 | COBERTURA | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 8.89 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 8.8902 cm
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 16.9 | 100 mm - 4" | Pluvial | 16.9
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 57.79 | 100 mm - 4" | Pluvial | 57.7942
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 16.6 | 100 mm - 4" | Pluvial | 16.5998
 | COBERTURA | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 373.71 | 100 mm - 4" | Pluvial | 373.71

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (18)
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa e luva simples; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa e luva simples
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede | PVC Esgoto - Luva - 40 mm | PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm (cm)
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 26.21 | 40 mm - 1.1/2" | Pluvial | 1 | 26.2097
 | TÉRREO | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 84.91 | 40 mm - 1.1/2" | Pluvial | 1 | 84.9116
 | PAVIMENTO 1 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 72.81 | 50 mm - 2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 72.8079 cm
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 31.81 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | 1 | 31.8128
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 60.65 | 40 mm - 1.1/2" | Pluvial | 1 | 60.646
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 262.99 | 40 mm - 1.1/2" | Pluvial | 1 | 262.986
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 29.01 | 40 mm - 1.1/2" | Pluvial | 1 | 29.0136
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 70.27 | 40 mm - 1.1/2" | Pluvial | 1 | 70.2713
 | PAVIMENTO 1 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 14.4 | 40 mm - 1.1/2" | Pluvial | 1 | 14.4
 | PAVIMENTO 1 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 66.64 | 50 mm - 2" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 66.6422 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 45.04 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.0415 cm
 | PAVIMENTO 2 | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 59.76 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 59.7649 cm
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 51.39 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | 1 | 51.3885
 | PAVIMENTO 2 | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 88.42 | 40 mm - 1.1/2" | Pluvial | 1 | 88.4219
 | COBERTURA | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 9.82 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.81745 cm
 | COBERTURA | 296.5 | 4.75 | ø2" | 0.16 | ø50 | 1 | 392.22 | 50 mm - 2" | Pluvial (Ar condicionado) | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 392.224 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | COBERTURA | 599.8 | 3.76 | ø1 1/2" | 0.12 | ø40 | 1 | 13.03 | 40 mm - 1.1/2" | Pluvial (Ar condicionado) | 1 | 13.0342
 | COBERTURA | 295.1 | 9.8 | ø4" | 0.18 | ø100 | 1 | 30.75 | 100 mm - 4" | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 30.7537 cm

# IfcPipeSegment: Tubos - diâmetro interno comercial (77)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Inclinação: 1
Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Rede: Pluvial (Ar condicionado); Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos - diâmetro interno comercial
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | PVC rígido soldável - Tubos - 32 mm (cm)
3 x  | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 19.81 | 32 mm | 19.8142
2 x  | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 27.37 | 32 mm | 27.3691
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 15.6 | 32 mm | 15.6
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 15.4 | 32 mm | 15.4
2 x  | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 41.18 | 40 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 41.1777 cm
2 x  | TÉRREO | 3.52 | ø1 1/4" | 0.24 | ø40 | 44.65 | 40 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 44.6506 cm
2 x  | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 25.6 | 32 mm | 25.6
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 25.4 | 32 mm | 25.4
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 25.63 | 32 mm | 25.6268
 | TÉRREO | 2.78 | ø1" | 0.21 | ø32 | 14 | 32 mm | 14
 | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 3.6 | 32 mm | 3.6
2 x  | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 62.62 | 32 mm | 62.622
2 x  | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 27.6 | 32 mm | 27.6
7 x  | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 25.63 | 32 mm | 25.6268
 | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 55.5 | 32 mm | 55.5014
 | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 3.4 | 32 mm | 3.4
4 x  | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 25.6 | 32 mm | 25.6
 | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 81.11 | 32 mm | 81.1076
3 x  | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 23.4 | 32 mm | 23.4
 | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 44.63 | 32 mm | 44.6349
2 x  | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 76.23 | 32 mm | 76.2296
2 x  | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 30.6 | 32 mm | 30.6
 | PAVIMENTO 1 | 2.78 | ø1" | 0.21 | ø32 | 25.4 | 32 mm | 25.4
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 32.07 | 32 mm | 32.073
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 269.1 | 32 mm | 269.1
6 x  | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 25.63 | 32 mm | 25.6268
3 x  | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 25.6 | 32 mm | 25.6
3 x  | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 19.81 | 32 mm | 19.8142
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 25.4 | 32 mm | 25.4
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 10.6 | 32 mm | 10.6
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 7.6 | 32 mm | 7.6
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 99.43 | 32 mm | 99.4264
2 x  | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 17.4 | 32 mm | 17.4
3 x  | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 13.6 | 32 mm | 13.6
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 62.62 | 32 mm | 62.622
 | PAVIMENTO 2 | 4.4 | ø1 1/2" | 0.3 | ø50 | 0.02 | 50 mm | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 56.72 | 32 mm | 56.7248
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 63.76 | 32 mm | 63.7609
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 563.18 | 32 mm | 563.183
2 x  | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 302.9 | 32 mm | 302.9
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 304.9 | 32 mm | 304.9
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 23.3 | 32 mm | 23.302
 | PAVIMENTO 2 | 2.78 | ø1" | 0.21 | ø32 | 5.6 | 32 mm | 5.6

# IfcValve: Válvula de retenção- superior (9)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Válvula de retenção- superior; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Válvula de retenção- superior; Rede: Pluvial
Pset_ValveTypeCommon - Reference: Válvula de retenção- superior
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Válvula de retenção - 100 mm: 1

# IfcWasteTerminal: Caixa de areia pluvial simples
In: TÉRREO
Type - PredefinedType: GULLYSUMP
AltoQi_Builder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CA-60x60 cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de alvenaria; Descrição: Caixa de areia pluvial simples; Nome: CA-60x60 cm; Classe: Caixas de Passagem; Tipo: Caixa de areia pluvial simples; Rede: Pluvial
Pset_WasteTerminalTypeCommon - Reference: Caixa de areia pluvial simples
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de areia pluvial sem grelha - CA- 60x60cm: 1

# IfcWasteTerminal: Ralo sifonado cilindrico normal (2)
In: COBERTURA
Type - PredefinedType: FLOORTRAP
AltoQi_Builder - Indicação: 100 mm - 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Ralo sifonado cilindrico normal; Nome: 100 mm - 40 mm; Classe: PVC Acessórios; Tipo: Ralo sifonado cilindrico normal; Rede: Pluvial (Ar condicionado)
Pset_WasteTerminalTypeCommon - Reference: Ralo sifonado cilindrico normal
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo sifonado alt. reg. saída 40 - 100 mm - 40 mm: 1

# IfcWasteTerminal: Ralos pluviais (12)
Type - PredefinedType: FLOORTRAP
AltoQi_Builder - Indicação: Ralo abacaxi- 100mm; Posição: Direta
Identificação_Elemento - Descrição: Ralos pluviais; Nome: Ralo abacaxi- 100mm; Classe: PVC Esgoto; Tipo: Ralos pluviais; Rede: Pluvial
Pset_WasteTerminalTypeCommon - Reference: Ralos pluviais
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo abacaxi - 100mm: 1
Name | In | Aplicação
 | PAVIMENTO 1 | Coletor pluvial | AltoQi_Builder - Comprimento: 5 cm; Diâmetro: 10 cm; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 100 mm: 1
 | PAVIMENTO 2 | Coletor pluvial | AltoQi_Builder - Comprimento: 5 cm; Diâmetro: 10 cm; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 100 mm: 1
 | COBERTURA | Coletor pluvial | AltoQi_Builder - Comprimento: 5 cm; Diâmetro: 10 cm; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 100 mm: 1
9 x  | COBERTURA | Conexão
